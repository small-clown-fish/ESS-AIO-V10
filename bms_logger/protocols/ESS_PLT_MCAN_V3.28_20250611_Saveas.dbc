VERSION ""

NS_ :

BS_:

BU_: MBMU PC SBMU IMM ETH DCDC LEMS

BO_ 2149547848 D2P_ALARM__08: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547849 D2P_ALARM__09: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547850 D2P_ALARM__10: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547851 D2P_ALARM__11: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547852 D2P_ALARM__12: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547853 D2P_ALARM__13: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547854 D2P_ALARM__14: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547855 D2P_ALARM__15: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547856 D2P_ALARM__16: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547857 D2P_ALARM__17: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547858 D2P_ALARM__18: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547859 D2P_ALARM__19: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547860 D2P_ALARM__20: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547861 D2P_ALARM__21: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547862 D2P_ALARM__22: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547863 D2P_ALARM__23: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547864 D2P_ALARM__24: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547865 D2P_ALARM__25: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547866 D2P_ALARM__26: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547867 D2P_ALARM__27: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547868 D2P_ALARM__28: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547869 D2P_ALARM__29: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547870 D2P_ALARM__30: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547871 D2P_ALARM__31: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547872 D2P_ALARM__32: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547873 D2P_ALARM__33: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547874 D2P_ALARM__34: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547875 D2P_ALARM__35: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547876 D2P_ALARM__36: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547877 D2P_ALARM__37: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

BO_ 2149547878 D2P_ALARM__38: 8 DCDC
 SG_ D2P_ALARM_EnvExtreOverTemp : 0|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_EnvOverTemp : 1|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosOverTemp : 2|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MosExtreOverTemp : 3|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverVolt : 4|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideUnderVolt : 5|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverVolt : 6|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HighSideOverCurr : 7|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_HW : 8|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowSideOverCurr_SW : 9|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_HW : 10|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_SecSideOverCurr_SW : 11|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_HW : 12|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_PriSideOverCurr_SW : 13|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_LowPowerSupplyErr : 14|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_MBMUComErr : 15|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCMsTeSaplgErr : 16|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_DCDCTeSaplgErr : 17|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_VoltSamplingErr : 18|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_HgSdCuSaplgErr : 19|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_CtrlCurrSamplingErr : 20|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_BypassFail : 21|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve1 : 22|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve2 : 23|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve3 : 24|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve4 : 25|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve5 : 26|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve6 : 27|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve7 : 28|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve8 : 29|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve9 : 30|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve10 : 31|1@1+ (1,0) [0|1] ""  PC
 SG_ D2P_ALARM_Reserve11 : 32|32@1+ (1,0) [0|4294967295] ""  PC

CM_ SG_ 2149547848 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547848 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547848 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547848 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547848 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547848 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547848 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547848 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547848 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547848 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547848 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547848 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547848 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547848 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547848 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547848 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547848 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547848 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547848 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547848 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547848 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547848 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547848 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547848 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547849 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547849 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547849 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547849 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547849 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547849 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547849 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547849 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547849 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547849 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547849 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547849 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547849 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547849 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547849 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547849 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547849 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547849 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547849 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547849 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547849 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547849 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547849 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547850 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547850 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547850 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547850 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547850 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547850 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547850 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547850 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547850 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547850 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547850 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547850 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547850 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547850 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547850 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547850 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547850 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547850 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547850 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547850 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547850 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547850 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547850 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547851 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547851 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547851 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547851 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547851 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547851 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547851 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547851 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547851 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547851 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547851 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547851 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547851 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547851 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547851 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547851 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547851 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547851 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547851 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547851 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547851 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547851 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547851 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547852 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547852 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547852 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547852 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547852 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547852 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547852 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547852 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547852 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547852 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547852 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547852 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547852 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547852 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547852 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547852 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547852 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547852 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547852 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547852 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547852 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547852 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547852 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547853 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547853 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547853 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547853 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547853 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547853 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547853 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547853 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547853 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547853 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547853 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547853 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547853 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547853 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547853 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547853 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547853 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547853 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547853 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547853 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547853 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547853 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547853 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547854 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547854 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547854 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547854 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547854 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547854 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547854 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547854 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547854 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547854 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547854 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547854 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547854 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547854 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547854 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547854 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547854 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547854 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547854 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547854 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547854 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547854 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547854 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547855 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547855 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547855 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547855 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547855 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547855 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547855 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547855 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547855 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547855 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547855 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547855 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547855 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547855 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547855 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547855 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547855 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547855 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547855 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547855 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547855 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547855 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547855 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547856 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547856 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547856 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547856 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547856 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547856 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547856 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547856 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547856 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547856 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547856 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547856 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547856 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547856 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547856 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547856 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547856 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547856 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547856 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547856 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547856 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547856 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547856 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547857 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547857 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547857 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547857 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547857 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547857 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547857 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547857 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547857 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547857 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547857 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547857 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547857 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547857 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547857 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547857 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547857 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547857 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547857 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547857 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547857 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547857 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547857 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547858 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547858 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547858 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547858 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547858 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547858 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547858 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547858 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547858 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547858 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547858 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547858 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547858 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547858 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547858 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547858 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547858 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547858 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547858 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547858 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547858 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547858 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547858 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547859 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547859 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547859 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547859 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547859 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547859 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547859 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547859 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547859 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547859 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547859 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547859 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547859 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547859 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547859 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547859 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547859 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547859 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547859 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547859 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547859 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547859 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547859 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547860 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547860 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547860 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547860 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547860 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547860 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547860 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547860 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547860 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547860 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547860 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547860 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547860 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547860 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547860 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547860 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547860 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547860 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547860 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547860 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547860 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547860 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547860 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547861 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547861 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547861 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547861 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547861 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547861 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547861 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547861 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547861 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547861 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547861 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547861 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547861 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547861 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547861 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547861 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547861 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547861 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547861 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547861 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547861 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547861 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547861 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547862 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547862 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547862 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547862 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547862 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547862 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547862 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547862 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547862 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547862 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547862 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547862 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547862 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547862 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547862 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547862 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547862 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547862 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547862 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547862 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547862 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547862 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547862 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547863 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547863 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547863 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547863 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547863 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547863 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547863 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547863 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547863 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547863 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547863 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547863 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547863 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547863 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547863 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547863 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547863 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547863 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547863 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547863 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547863 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547863 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547863 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547864 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547864 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547864 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547864 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547864 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547864 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547864 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547864 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547864 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547864 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547864 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547864 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547864 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547864 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547864 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547864 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547864 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547864 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547864 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547864 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547864 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547864 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547864 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547865 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547865 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547865 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547865 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547865 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547865 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547865 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547865 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547865 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547865 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547865 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547865 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547865 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547865 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547865 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547865 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547865 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547865 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547865 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547865 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547865 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547865 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547865 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547866 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547866 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547866 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547866 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547866 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547866 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547866 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547866 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547866 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547866 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547866 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547866 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547866 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547866 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547866 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547866 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547866 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547866 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547866 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547866 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547866 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547866 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547866 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547867 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547867 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547867 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547867 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547867 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547867 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547867 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547867 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547867 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547867 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547867 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547867 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547867 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547867 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547867 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547867 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547867 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547867 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547867 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547867 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547867 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547867 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547867 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547868 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547868 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547868 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547868 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547868 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547868 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547868 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547868 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547868 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547868 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547868 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547868 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547868 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547868 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547868 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547868 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547868 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547868 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547868 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547868 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547868 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547868 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547868 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547869 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547869 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547869 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547869 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547869 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547869 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547869 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547869 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547869 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547869 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547869 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547869 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547869 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547869 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547869 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547869 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547869 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547869 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547869 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547869 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547869 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547869 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547869 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547870 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547870 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547870 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547870 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547870 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547870 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547870 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547870 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547870 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547870 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547870 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547870 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547870 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547870 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547870 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547870 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547870 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547870 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547870 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547870 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547870 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547870 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547870 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547871 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547871 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547871 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547871 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547871 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547871 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547871 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547871 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547871 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547871 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547871 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547871 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547871 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547871 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547871 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547871 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547871 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547871 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547871 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547871 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547871 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547871 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547871 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547872 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547872 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547872 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547872 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547872 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547872 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547872 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547872 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547872 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547872 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547872 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547872 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547872 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547872 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547872 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547872 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547872 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547872 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547872 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547872 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547872 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547872 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547872 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547873 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547873 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547873 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547873 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547873 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547873 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547873 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547873 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547873 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547873 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547873 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547873 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547873 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547873 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547873 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547873 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547873 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547873 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547873 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547873 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547873 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547873 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547873 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547874 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547874 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547874 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547874 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547874 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547874 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547874 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547874 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547874 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547874 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547874 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547874 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547874 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547874 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547874 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547874 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547874 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547874 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547874 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547874 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547874 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547874 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547874 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547875 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547875 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547875 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547875 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547875 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547875 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547875 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547875 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547875 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547875 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547875 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547875 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547875 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547875 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547875 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547875 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547875 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547875 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547875 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547875 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547875 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547875 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547875 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547876 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547876 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547876 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547876 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547876 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547876 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547876 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547876 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547876 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547876 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547876 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547876 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547876 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547876 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547876 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547876 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547876 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547876 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547876 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547876 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547876 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547876 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547876 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547877 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547877 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547877 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547877 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547877 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547877 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547877 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547877 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547877 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547877 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547877 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547877 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547877 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547877 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547877 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547877 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547877 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547877 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547877 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547877 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547877 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547877 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547877 D2P_ALARM_Reserve11 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_EnvExtreOverTemp "环境极限过温";
CM_ SG_ 2149547878 D2P_ALARM_EnvOverTemp "环境过温";
CM_ SG_ 2149547878 D2P_ALARM_MosOverTemp "MOS管过温";
CM_ SG_ 2149547878 D2P_ALARM_MosExtreOverTemp "MOS管极限过温";
CM_ SG_ 2149547878 D2P_ALARM_HighSideOverVolt "高压侧过压故障";
CM_ SG_ 2149547878 D2P_ALARM_HighSideUnderVolt "高压侧欠压故障";
CM_ SG_ 2149547878 D2P_ALARM_LowSideOverVolt "低压侧过压故障";
CM_ SG_ 2149547878 D2P_ALARM_HighSideOverCurr "高压侧过流故障";
CM_ SG_ 2149547878 D2P_ALARM_LowSideOverCurr_HW "低压侧硬件过流故障";
CM_ SG_ 2149547878 D2P_ALARM_LowSideOverCurr_SW "低压侧软件过流故障";
CM_ SG_ 2149547878 D2P_ALARM_SecSideOverCurr_HW "谐振腔副边硬件过流";
CM_ SG_ 2149547878 D2P_ALARM_SecSideOverCurr_SW "谐振腔副边软件过流";
CM_ SG_ 2149547878 D2P_ALARM_PriSideOverCurr_HW "谐振腔源边硬件过流";
CM_ SG_ 2149547878 D2P_ALARM_PriSideOverCurr_SW "谐振腔源边软件过流";
CM_ SG_ 2149547878 D2P_ALARM_LowPowerSupplyErr "低压电源供电异常";
CM_ SG_ 2149547878 D2P_ALARM_MBMUComErr "MBMU通讯故障";
CM_ SG_ 2149547878 D2P_ALARM_DCDCMsTeSaplgErr "DCDCMOS管采样温度异常（单点）";
CM_ SG_ 2149547878 D2P_ALARM_DCDCTeSaplgErr "DCDC温度采样异常（双点及以上)";
CM_ SG_ 2149547878 D2P_ALARM_VoltSamplingErr "电压采样异常";
CM_ SG_ 2149547878 D2P_ALARM_HgSdCuSaplgErr "高压侧电流采样异常";
CM_ SG_ 2149547878 D2P_ALARM_CtrlCurrSamplingErr "控制电流采样异常";
CM_ SG_ 2149547878 D2P_ALARM_BypassFail "切旁路失败";
CM_ SG_ 2149547878 D2P_ALARM_Reserve1 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve2 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve3 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve4 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve5 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve6 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve7 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve8 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve9 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve10 "预留数据";
CM_ SG_ 2149547878 D2P_ALARM_Reserve11 "预留数据";
VAL_ 2149547848 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547848 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547849 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547850 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547851 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547852 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547853 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547854 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547855 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547856 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547857 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547858 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547859 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547860 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547861 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547862 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547863 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547864 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547865 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547866 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547867 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547868 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547869 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547870 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547871 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547872 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547873 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547874 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547875 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547876 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547877 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_EnvExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_EnvOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_MosOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_MosExtreOverTemp 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_HighSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_HighSideUnderVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_LowSideOverVolt 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_HighSideOverCurr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_LowSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_LowSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_SecSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_SecSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_PriSideOverCurr_HW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_PriSideOverCurr_SW 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_LowPowerSupplyErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_MBMUComErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_DCDCMsTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_DCDCTeSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_VoltSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_HgSdCuSaplgErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_CtrlCurrSamplingErr 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_BypassFail 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve1 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve2 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve3 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve4 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve5 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve6 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve7 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve8 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve9 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve10 0 "No Alarm" 1 "Alarm Occur" ;
VAL_ 2149547878 D2P_ALARM_Reserve11 0 "No Alarm" 1 "Alarm Occur" ;
