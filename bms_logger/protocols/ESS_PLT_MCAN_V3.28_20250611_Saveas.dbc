VERSION ""

NS_ :

BS_:

BU_: MBMU PC SBMU IMM ETH DCDC LEMS

BO_ 2400841299 S2P_Detail_Ucell20__19: 8 SBMU
 SG_ CSC_U_No_19 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_19 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_19 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_19 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_19 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_19 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_19 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_19 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_19 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_19 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_19 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_19 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_19 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_19 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_19 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_19 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_19 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_19 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_19 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_19 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_19 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_19 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_19 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_19 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_19 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_19 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_19 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_19 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_19 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_19 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_19 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_19 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_19 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_19 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_19 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_19 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_19 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_19 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_19 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_19 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_19 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_19 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_19 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_19 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_19 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_19 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_19 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_19 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_19 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_19 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_19 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_19 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_19 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841300 S2P_Detail_Ucell20__20: 8 SBMU
 SG_ CSC_U_No_20 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_20 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_20 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_20 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_20 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_20 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_20 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_20 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_20 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_20 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_20 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_20 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_20 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_20 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_20 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_20 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_20 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_20 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_20 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_20 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_20 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_20 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_20 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_20 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_20 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_20 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_20 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_20 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_20 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_20 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_20 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_20 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_20 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_20 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_20 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_20 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_20 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_20 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_20 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_20 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_20 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_20 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_20 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_20 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_20 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_20 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_20 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_20 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_20 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_20 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_20 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_20 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_20 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841301 S2P_Detail_Ucell20__21: 8 SBMU
 SG_ CSC_U_No_21 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_21 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_21 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_21 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_21 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_21 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_21 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_21 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_21 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_21 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_21 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_21 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_21 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_21 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_21 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_21 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_21 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_21 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_21 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_21 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_21 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_21 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_21 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_21 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_21 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_21 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_21 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_21 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_21 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_21 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_21 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_21 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_21 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_21 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_21 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_21 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_21 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_21 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_21 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_21 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_21 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_21 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_21 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_21 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_21 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_21 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_21 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_21 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_21 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_21 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_21 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_21 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_21 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841302 S2P_Detail_Ucell20__22: 8 SBMU
 SG_ CSC_U_No_22 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_22 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_22 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_22 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_22 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_22 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_22 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_22 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_22 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_22 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_22 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_22 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_22 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_22 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_22 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_22 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_22 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_22 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_22 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_22 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_22 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_22 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_22 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_22 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_22 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_22 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_22 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_22 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_22 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_22 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_22 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_22 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_22 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_22 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_22 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_22 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_22 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_22 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_22 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_22 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_22 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_22 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_22 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_22 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_22 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_22 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_22 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_22 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_22 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_22 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_22 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_22 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_22 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841303 S2P_Detail_Ucell20__23: 8 SBMU
 SG_ CSC_U_No_23 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_23 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_23 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_23 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_23 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_23 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_23 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_23 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_23 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_23 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_23 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_23 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_23 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_23 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_23 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_23 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_23 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_23 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_23 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_23 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_23 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_23 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_23 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_23 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_23 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_23 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_23 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_23 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_23 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_23 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_23 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_23 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_23 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_23 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_23 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_23 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_23 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_23 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_23 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_23 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_23 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_23 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_23 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_23 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_23 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_23 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_23 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_23 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_23 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_23 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_23 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_23 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_23 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841304 S2P_Detail_Ucell20__24: 8 SBMU
 SG_ CSC_U_No_24 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_24 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_24 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_24 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_24 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_24 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_24 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_24 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_24 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_24 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_24 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_24 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_24 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_24 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_24 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_24 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_24 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_24 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_24 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_24 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_24 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_24 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_24 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_24 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_24 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_24 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_24 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_24 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_24 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_24 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_24 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_24 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_24 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_24 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_24 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_24 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_24 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_24 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_24 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_24 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_24 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_24 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_24 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_24 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_24 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_24 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_24 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_24 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_24 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_24 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_24 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_24 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_24 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841305 S2P_Detail_Ucell20__25: 8 SBMU
 SG_ CSC_U_No_25 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_25 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_25 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_25 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_25 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_25 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_25 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_25 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_25 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_25 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_25 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_25 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_25 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_25 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_25 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_25 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_25 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_25 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_25 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_25 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_25 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_25 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_25 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_25 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_25 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_25 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_25 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_25 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_25 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_25 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_25 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_25 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_25 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_25 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_25 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_25 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_25 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_25 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_25 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_25 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_25 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_25 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_25 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_25 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_25 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_25 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_25 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_25 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_25 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_25 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_25 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_25 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_25 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841306 S2P_Detail_Ucell20__26: 8 SBMU
 SG_ CSC_U_No_26 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_26 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_26 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_26 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_26 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_26 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_26 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_26 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_26 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_26 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_26 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_26 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_26 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_26 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_26 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_26 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_26 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_26 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_26 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_26 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_26 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_26 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_26 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_26 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_26 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_26 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_26 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_26 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_26 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_26 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_26 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_26 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_26 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_26 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_26 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_26 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_26 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_26 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_26 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_26 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_26 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_26 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_26 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_26 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_26 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_26 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_26 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_26 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_26 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_26 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_26 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_26 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_26 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841307 S2P_Detail_Ucell20__27: 8 SBMU
 SG_ CSC_U_No_27 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_27 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_27 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_27 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_27 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_27 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_27 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_27 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_27 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_27 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_27 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_27 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_27 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_27 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_27 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_27 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_27 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_27 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_27 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_27 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_27 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_27 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_27 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_27 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_27 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_27 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_27 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_27 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_27 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_27 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_27 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_27 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_27 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_27 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_27 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_27 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_27 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_27 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_27 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_27 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_27 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_27 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_27 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_27 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_27 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_27 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_27 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_27 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_27 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_27 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_27 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_27 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_27 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841308 S2P_Detail_Ucell20__28: 8 SBMU
 SG_ CSC_U_No_28 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_28 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_28 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_28 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_28 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_28 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_28 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_28 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_28 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_28 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_28 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_28 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_28 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_28 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_28 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_28 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_28 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_28 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_28 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_28 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_28 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_28 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_28 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_28 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_28 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_28 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_28 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_28 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_28 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_28 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_28 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_28 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_28 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_28 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_28 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_28 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_28 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_28 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_28 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_28 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_28 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_28 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_28 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_28 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_28 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_28 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_28 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_28 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_28 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_28 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_28 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_28 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_28 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841309 S2P_Detail_Ucell20__29: 8 SBMU
 SG_ CSC_U_No_29 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_29 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_29 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_29 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_29 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_29 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_29 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_29 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_29 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_29 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_29 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_29 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_29 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_29 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_29 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_29 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_29 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_29 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_29 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_29 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_29 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_29 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_29 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_29 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_29 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_29 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_29 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_29 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_29 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_29 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_29 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_29 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_29 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_29 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_29 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_29 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_29 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_29 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_29 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_29 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_29 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_29 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_29 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_29 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_29 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_29 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_29 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_29 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_29 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_29 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_29 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_29 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_29 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841310 S2P_Detail_Ucell20__30: 8 SBMU
 SG_ CSC_U_No_30 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_30 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_30 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_30 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_30 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_30 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_30 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_30 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_30 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_30 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_30 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_30 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_30 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_30 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_30 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_30 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_30 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_30 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_30 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_30 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_30 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_30 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_30 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_30 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_30 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_30 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_30 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_30 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_30 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_30 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_30 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_30 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_30 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_30 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_30 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_30 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_30 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_30 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_30 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_30 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_30 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_30 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_30 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_30 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_30 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_30 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_30 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_30 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_30 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_30 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_30 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_30 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_30 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841311 S2P_Detail_Ucell20__31: 8 SBMU
 SG_ CSC_U_No_31 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_31 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_31 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_31 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_31 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_31 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_31 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_31 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_31 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_31 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_31 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_31 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_31 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_31 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_31 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_31 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_31 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_31 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_31 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_31 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_31 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_31 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_31 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_31 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_31 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_31 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_31 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_31 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_31 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_31 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_31 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_31 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_31 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_31 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_31 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_31 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_31 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_31 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_31 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_31 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_31 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_31 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_31 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_31 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_31 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_31 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_31 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_31 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_31 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_31 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_31 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_31 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_31 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841312 S2P_Detail_Ucell20__32: 8 SBMU
 SG_ CSC_U_No_32 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_32 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_32 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_32 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_32 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_32 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_32 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_32 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_32 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_32 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_32 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_32 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_32 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_32 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_32 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_32 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_32 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_32 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_32 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_32 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_32 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_32 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_32 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_32 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_32 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_32 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_32 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_32 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_32 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_32 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_32 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_32 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_32 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_32 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_32 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_32 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_32 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_32 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_32 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_32 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_32 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_32 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_32 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_32 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_32 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_32 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_32 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_32 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_32 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_32 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_32 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_32 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_32 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841313 S2P_Detail_Ucell20__33: 8 SBMU
 SG_ CSC_U_No_33 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_33 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_33 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_33 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_33 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_33 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_33 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_33 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_33 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_33 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_33 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_33 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_33 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_33 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_33 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_33 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_33 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_33 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_33 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_33 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_33 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_33 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_33 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_33 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_33 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_33 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_33 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_33 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_33 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_33 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_33 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_33 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_33 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_33 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_33 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_33 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_33 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_33 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_33 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_33 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_33 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_33 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_33 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_33 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_33 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_33 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_33 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_33 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_33 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_33 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_33 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_33 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_33 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841314 S2P_Detail_Ucell20__34: 8 SBMU
 SG_ CSC_U_No_34 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_34 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_34 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_34 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_34 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_34 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_34 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_34 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_34 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_34 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_34 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_34 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_34 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_34 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_34 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_34 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_34 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_34 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_34 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_34 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_34 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_34 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_34 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_34 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_34 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_34 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_34 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_34 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_34 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_34 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_34 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_34 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_34 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_34 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_34 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_34 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_34 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_34 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_34 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_34 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_34 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_34 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_34 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_34 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_34 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_34 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_34 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_34 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_34 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_34 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_34 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_34 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_34 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841315 S2P_Detail_Ucell20__35: 8 SBMU
 SG_ CSC_U_No_35 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_35 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_35 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_35 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_35 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_35 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_35 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_35 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_35 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_35 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_35 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_35 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_35 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_35 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_35 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_35 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_35 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_35 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_35 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_35 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_35 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_35 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_35 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_35 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_35 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_35 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_35 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_35 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_35 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_35 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_35 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_35 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_35 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_35 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_35 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_35 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_35 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_35 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_35 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_35 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_35 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_35 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_35 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_35 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_35 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_35 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_35 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_35 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_35 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_35 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_35 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_35 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_35 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841316 S2P_Detail_Ucell20__36: 8 SBMU
 SG_ CSC_U_No_36 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_36 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_36 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_36 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_36 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_36 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_36 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_36 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_36 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_36 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_36 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_36 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_36 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_36 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_36 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_36 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_36 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_36 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_36 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_36 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_36 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_36 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_36 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_36 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_36 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_36 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_36 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_36 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_36 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_36 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_36 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_36 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_36 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_36 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_36 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_36 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_36 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_36 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_36 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_36 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_36 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_36 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_36 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_36 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_36 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_36 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_36 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_36 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_36 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_36 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_36 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_36 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_36 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841317 S2P_Detail_Ucell20__37: 8 SBMU
 SG_ CSC_U_No_37 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_37 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_37 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_37 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_37 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_37 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_37 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_37 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_37 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_37 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_37 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_37 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_37 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_37 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_37 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_37 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_37 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_37 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_37 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_37 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_37 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_37 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_37 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_37 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_37 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_37 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_37 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_37 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_37 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_37 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_37 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_37 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_37 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_37 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_37 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_37 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_37 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_37 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_37 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_37 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_37 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_37 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_37 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_37 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_37 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_37 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_37 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_37 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_37 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_37 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_37 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_37 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_37 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841318 S2P_Detail_Ucell20__38: 8 SBMU
 SG_ CSC_U_No_38 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_38 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_38 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_38 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_38 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_38 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_38 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_38 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_38 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_38 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_38 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_38 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_38 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_38 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_38 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_38 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_38 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_38 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_38 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_38 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_38 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_38 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_38 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_38 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_38 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_38 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_38 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_38 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_38 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_38 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_38 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_38 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_38 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_38 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_38 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_38 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_38 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_38 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_38 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_38 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_38 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_38 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_38 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_38 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_38 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_38 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_38 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_38 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_38 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_38 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_38 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_38 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_38 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841319 S2P_Detail_Ucell20__39: 8 SBMU
 SG_ CSC_U_No_39 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_39 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_39 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_39 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_39 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_39 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_39 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_39 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_39 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_39 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_39 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_39 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_39 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_39 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_39 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_39 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_39 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_39 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_39 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_39 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_39 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_39 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_39 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_39 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_39 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_39 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_39 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_39 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_39 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_39 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_39 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_39 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_39 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_39 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_39 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_39 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_39 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_39 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_39 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_39 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_39 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_39 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_39 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_39 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_39 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_39 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_39 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_39 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_39 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_39 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_39 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_39 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_39 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

BO_ 2400841320 S2P_Detail_Ucell20__40: 8 SBMU
 SG_ CSC_U_No_40 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_40 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_58_40 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_59_40 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_60_40 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_61_40 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_62_40 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_63_40 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_64_40 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_65_40 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_66_40 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_67_40 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_68_40 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_69_40 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_70_40 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_71_40 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_72_40 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_73_40 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_74_40 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_75_40 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_76_40 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_77_40 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_78_40 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_79_40 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_80_40 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_81_40 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_82_40 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_83_40 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_84_40 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_85_40 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_86_40 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_87_40 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_88_40 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_89_40 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_90_40 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_91_40 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_92_40 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_93_40 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_94_40 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_95_40 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_96_40 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_97_40 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_98_40 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_99_40 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_100_40 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_101_40 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_102_40 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_103_40 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_104_40 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_105_40 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_106_40 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_107_40 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_108_40 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC

CM_ SG_ 2400841299 CSC_U_No_19 "CSC号";
CM_ SG_ 2400841299 CSC_Ucell_Frame_Index_19 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841299 CSC_Ucell_58_19 "58 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_59_19 "59 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_60_19 "60 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_61_19 "61 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_62_19 "62 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_63_19 "63 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_64_19 "64 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_65_19 "65 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_66_19 "66 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_67_19 "67 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_68_19 "68 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_69_19 "69 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_70_19 "70 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_71_19 "71 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_72_19 "72 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_73_19 "73 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_74_19 "74 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_75_19 "75 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_76_19 "76 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_77_19 "77 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_78_19 "78 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_79_19 "79 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_80_19 "80 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_81_19 "81 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_82_19 "82 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_83_19 "83 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_84_19 "84 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_85_19 "85 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_86_19 "86 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_87_19 "87 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_88_19 "88 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_89_19 "89 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_90_19 "90 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_91_19 "91 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_92_19 "92 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_93_19 "93 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_94_19 "94 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_95_19 "95 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_96_19 "96 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_97_19 "97 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_98_19 "98 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_99_19 "99 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_100_19 "100 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_101_19 "101 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_102_19 "102 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_103_19 "103 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_104_19 "104 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_105_19 "105 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_106_19 "106 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_107_19 "107 电池单体电压";
CM_ SG_ 2400841299 CSC_Ucell_108_19 "108 电池单体电压";
CM_ SG_ 2400841300 CSC_U_No_20 "CSC号";
CM_ SG_ 2400841300 CSC_Ucell_Frame_Index_20 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841300 CSC_Ucell_58_20 "58 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_59_20 "59 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_60_20 "60 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_61_20 "61 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_62_20 "62 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_63_20 "63 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_64_20 "64 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_65_20 "65 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_66_20 "66 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_67_20 "67 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_68_20 "68 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_69_20 "69 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_70_20 "70 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_71_20 "71 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_72_20 "72 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_73_20 "73 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_74_20 "74 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_75_20 "75 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_76_20 "76 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_77_20 "77 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_78_20 "78 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_79_20 "79 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_80_20 "80 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_81_20 "81 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_82_20 "82 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_83_20 "83 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_84_20 "84 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_85_20 "85 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_86_20 "86 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_87_20 "87 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_88_20 "88 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_89_20 "89 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_90_20 "90 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_91_20 "91 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_92_20 "92 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_93_20 "93 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_94_20 "94 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_95_20 "95 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_96_20 "96 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_97_20 "97 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_98_20 "98 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_99_20 "99 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_100_20 "100 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_101_20 "101 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_102_20 "102 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_103_20 "103 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_104_20 "104 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_105_20 "105 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_106_20 "106 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_107_20 "107 电池单体电压";
CM_ SG_ 2400841300 CSC_Ucell_108_20 "108 电池单体电压";
CM_ SG_ 2400841301 CSC_U_No_21 "CSC号";
CM_ SG_ 2400841301 CSC_Ucell_Frame_Index_21 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841301 CSC_Ucell_58_21 "58 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_59_21 "59 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_60_21 "60 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_61_21 "61 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_62_21 "62 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_63_21 "63 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_64_21 "64 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_65_21 "65 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_66_21 "66 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_67_21 "67 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_68_21 "68 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_69_21 "69 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_70_21 "70 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_71_21 "71 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_72_21 "72 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_73_21 "73 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_74_21 "74 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_75_21 "75 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_76_21 "76 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_77_21 "77 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_78_21 "78 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_79_21 "79 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_80_21 "80 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_81_21 "81 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_82_21 "82 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_83_21 "83 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_84_21 "84 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_85_21 "85 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_86_21 "86 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_87_21 "87 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_88_21 "88 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_89_21 "89 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_90_21 "90 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_91_21 "91 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_92_21 "92 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_93_21 "93 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_94_21 "94 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_95_21 "95 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_96_21 "96 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_97_21 "97 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_98_21 "98 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_99_21 "99 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_100_21 "100 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_101_21 "101 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_102_21 "102 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_103_21 "103 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_104_21 "104 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_105_21 "105 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_106_21 "106 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_107_21 "107 电池单体电压";
CM_ SG_ 2400841301 CSC_Ucell_108_21 "108 电池单体电压";
CM_ SG_ 2400841302 CSC_U_No_22 "CSC号";
CM_ SG_ 2400841302 CSC_Ucell_Frame_Index_22 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841302 CSC_Ucell_58_22 "58 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_59_22 "59 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_60_22 "60 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_61_22 "61 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_62_22 "62 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_63_22 "63 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_64_22 "64 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_65_22 "65 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_66_22 "66 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_67_22 "67 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_68_22 "68 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_69_22 "69 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_70_22 "70 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_71_22 "71 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_72_22 "72 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_73_22 "73 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_74_22 "74 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_75_22 "75 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_76_22 "76 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_77_22 "77 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_78_22 "78 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_79_22 "79 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_80_22 "80 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_81_22 "81 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_82_22 "82 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_83_22 "83 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_84_22 "84 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_85_22 "85 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_86_22 "86 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_87_22 "87 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_88_22 "88 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_89_22 "89 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_90_22 "90 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_91_22 "91 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_92_22 "92 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_93_22 "93 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_94_22 "94 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_95_22 "95 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_96_22 "96 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_97_22 "97 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_98_22 "98 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_99_22 "99 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_100_22 "100 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_101_22 "101 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_102_22 "102 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_103_22 "103 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_104_22 "104 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_105_22 "105 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_106_22 "106 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_107_22 "107 电池单体电压";
CM_ SG_ 2400841302 CSC_Ucell_108_22 "108 电池单体电压";
CM_ SG_ 2400841303 CSC_U_No_23 "CSC号";
CM_ SG_ 2400841303 CSC_Ucell_Frame_Index_23 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841303 CSC_Ucell_58_23 "58 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_59_23 "59 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_60_23 "60 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_61_23 "61 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_62_23 "62 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_63_23 "63 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_64_23 "64 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_65_23 "65 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_66_23 "66 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_67_23 "67 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_68_23 "68 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_69_23 "69 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_70_23 "70 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_71_23 "71 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_72_23 "72 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_73_23 "73 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_74_23 "74 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_75_23 "75 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_76_23 "76 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_77_23 "77 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_78_23 "78 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_79_23 "79 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_80_23 "80 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_81_23 "81 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_82_23 "82 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_83_23 "83 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_84_23 "84 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_85_23 "85 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_86_23 "86 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_87_23 "87 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_88_23 "88 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_89_23 "89 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_90_23 "90 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_91_23 "91 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_92_23 "92 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_93_23 "93 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_94_23 "94 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_95_23 "95 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_96_23 "96 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_97_23 "97 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_98_23 "98 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_99_23 "99 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_100_23 "100 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_101_23 "101 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_102_23 "102 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_103_23 "103 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_104_23 "104 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_105_23 "105 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_106_23 "106 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_107_23 "107 电池单体电压";
CM_ SG_ 2400841303 CSC_Ucell_108_23 "108 电池单体电压";
CM_ SG_ 2400841304 CSC_U_No_24 "CSC号";
CM_ SG_ 2400841304 CSC_Ucell_Frame_Index_24 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841304 CSC_Ucell_58_24 "58 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_59_24 "59 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_60_24 "60 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_61_24 "61 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_62_24 "62 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_63_24 "63 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_64_24 "64 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_65_24 "65 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_66_24 "66 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_67_24 "67 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_68_24 "68 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_69_24 "69 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_70_24 "70 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_71_24 "71 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_72_24 "72 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_73_24 "73 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_74_24 "74 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_75_24 "75 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_76_24 "76 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_77_24 "77 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_78_24 "78 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_79_24 "79 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_80_24 "80 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_81_24 "81 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_82_24 "82 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_83_24 "83 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_84_24 "84 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_85_24 "85 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_86_24 "86 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_87_24 "87 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_88_24 "88 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_89_24 "89 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_90_24 "90 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_91_24 "91 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_92_24 "92 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_93_24 "93 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_94_24 "94 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_95_24 "95 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_96_24 "96 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_97_24 "97 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_98_24 "98 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_99_24 "99 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_100_24 "100 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_101_24 "101 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_102_24 "102 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_103_24 "103 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_104_24 "104 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_105_24 "105 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_106_24 "106 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_107_24 "107 电池单体电压";
CM_ SG_ 2400841304 CSC_Ucell_108_24 "108 电池单体电压";
CM_ SG_ 2400841305 CSC_U_No_25 "CSC号";
CM_ SG_ 2400841305 CSC_Ucell_Frame_Index_25 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841305 CSC_Ucell_58_25 "58 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_59_25 "59 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_60_25 "60 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_61_25 "61 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_62_25 "62 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_63_25 "63 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_64_25 "64 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_65_25 "65 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_66_25 "66 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_67_25 "67 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_68_25 "68 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_69_25 "69 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_70_25 "70 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_71_25 "71 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_72_25 "72 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_73_25 "73 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_74_25 "74 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_75_25 "75 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_76_25 "76 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_77_25 "77 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_78_25 "78 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_79_25 "79 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_80_25 "80 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_81_25 "81 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_82_25 "82 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_83_25 "83 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_84_25 "84 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_85_25 "85 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_86_25 "86 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_87_25 "87 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_88_25 "88 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_89_25 "89 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_90_25 "90 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_91_25 "91 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_92_25 "92 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_93_25 "93 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_94_25 "94 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_95_25 "95 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_96_25 "96 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_97_25 "97 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_98_25 "98 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_99_25 "99 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_100_25 "100 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_101_25 "101 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_102_25 "102 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_103_25 "103 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_104_25 "104 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_105_25 "105 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_106_25 "106 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_107_25 "107 电池单体电压";
CM_ SG_ 2400841305 CSC_Ucell_108_25 "108 电池单体电压";
CM_ SG_ 2400841306 CSC_U_No_26 "CSC号";
CM_ SG_ 2400841306 CSC_Ucell_Frame_Index_26 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841306 CSC_Ucell_58_26 "58 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_59_26 "59 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_60_26 "60 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_61_26 "61 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_62_26 "62 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_63_26 "63 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_64_26 "64 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_65_26 "65 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_66_26 "66 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_67_26 "67 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_68_26 "68 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_69_26 "69 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_70_26 "70 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_71_26 "71 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_72_26 "72 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_73_26 "73 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_74_26 "74 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_75_26 "75 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_76_26 "76 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_77_26 "77 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_78_26 "78 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_79_26 "79 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_80_26 "80 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_81_26 "81 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_82_26 "82 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_83_26 "83 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_84_26 "84 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_85_26 "85 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_86_26 "86 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_87_26 "87 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_88_26 "88 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_89_26 "89 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_90_26 "90 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_91_26 "91 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_92_26 "92 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_93_26 "93 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_94_26 "94 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_95_26 "95 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_96_26 "96 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_97_26 "97 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_98_26 "98 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_99_26 "99 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_100_26 "100 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_101_26 "101 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_102_26 "102 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_103_26 "103 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_104_26 "104 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_105_26 "105 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_106_26 "106 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_107_26 "107 电池单体电压";
CM_ SG_ 2400841306 CSC_Ucell_108_26 "108 电池单体电压";
CM_ SG_ 2400841307 CSC_U_No_27 "CSC号";
CM_ SG_ 2400841307 CSC_Ucell_Frame_Index_27 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841307 CSC_Ucell_58_27 "58 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_59_27 "59 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_60_27 "60 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_61_27 "61 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_62_27 "62 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_63_27 "63 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_64_27 "64 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_65_27 "65 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_66_27 "66 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_67_27 "67 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_68_27 "68 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_69_27 "69 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_70_27 "70 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_71_27 "71 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_72_27 "72 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_73_27 "73 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_74_27 "74 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_75_27 "75 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_76_27 "76 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_77_27 "77 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_78_27 "78 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_79_27 "79 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_80_27 "80 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_81_27 "81 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_82_27 "82 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_83_27 "83 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_84_27 "84 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_85_27 "85 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_86_27 "86 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_87_27 "87 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_88_27 "88 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_89_27 "89 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_90_27 "90 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_91_27 "91 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_92_27 "92 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_93_27 "93 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_94_27 "94 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_95_27 "95 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_96_27 "96 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_97_27 "97 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_98_27 "98 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_99_27 "99 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_100_27 "100 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_101_27 "101 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_102_27 "102 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_103_27 "103 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_104_27 "104 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_105_27 "105 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_106_27 "106 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_107_27 "107 电池单体电压";
CM_ SG_ 2400841307 CSC_Ucell_108_27 "108 电池单体电压";
CM_ SG_ 2400841308 CSC_U_No_28 "CSC号";
CM_ SG_ 2400841308 CSC_Ucell_Frame_Index_28 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841308 CSC_Ucell_58_28 "58 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_59_28 "59 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_60_28 "60 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_61_28 "61 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_62_28 "62 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_63_28 "63 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_64_28 "64 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_65_28 "65 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_66_28 "66 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_67_28 "67 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_68_28 "68 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_69_28 "69 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_70_28 "70 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_71_28 "71 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_72_28 "72 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_73_28 "73 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_74_28 "74 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_75_28 "75 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_76_28 "76 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_77_28 "77 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_78_28 "78 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_79_28 "79 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_80_28 "80 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_81_28 "81 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_82_28 "82 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_83_28 "83 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_84_28 "84 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_85_28 "85 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_86_28 "86 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_87_28 "87 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_88_28 "88 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_89_28 "89 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_90_28 "90 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_91_28 "91 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_92_28 "92 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_93_28 "93 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_94_28 "94 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_95_28 "95 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_96_28 "96 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_97_28 "97 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_98_28 "98 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_99_28 "99 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_100_28 "100 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_101_28 "101 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_102_28 "102 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_103_28 "103 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_104_28 "104 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_105_28 "105 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_106_28 "106 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_107_28 "107 电池单体电压";
CM_ SG_ 2400841308 CSC_Ucell_108_28 "108 电池单体电压";
CM_ SG_ 2400841309 CSC_U_No_29 "CSC号";
CM_ SG_ 2400841309 CSC_Ucell_Frame_Index_29 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841309 CSC_Ucell_58_29 "58 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_59_29 "59 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_60_29 "60 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_61_29 "61 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_62_29 "62 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_63_29 "63 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_64_29 "64 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_65_29 "65 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_66_29 "66 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_67_29 "67 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_68_29 "68 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_69_29 "69 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_70_29 "70 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_71_29 "71 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_72_29 "72 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_73_29 "73 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_74_29 "74 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_75_29 "75 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_76_29 "76 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_77_29 "77 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_78_29 "78 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_79_29 "79 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_80_29 "80 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_81_29 "81 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_82_29 "82 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_83_29 "83 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_84_29 "84 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_85_29 "85 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_86_29 "86 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_87_29 "87 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_88_29 "88 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_89_29 "89 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_90_29 "90 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_91_29 "91 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_92_29 "92 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_93_29 "93 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_94_29 "94 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_95_29 "95 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_96_29 "96 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_97_29 "97 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_98_29 "98 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_99_29 "99 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_100_29 "100 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_101_29 "101 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_102_29 "102 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_103_29 "103 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_104_29 "104 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_105_29 "105 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_106_29 "106 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_107_29 "107 电池单体电压";
CM_ SG_ 2400841309 CSC_Ucell_108_29 "108 电池单体电压";
CM_ SG_ 2400841310 CSC_U_No_30 "CSC号";
CM_ SG_ 2400841310 CSC_Ucell_Frame_Index_30 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841310 CSC_Ucell_58_30 "58 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_59_30 "59 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_60_30 "60 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_61_30 "61 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_62_30 "62 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_63_30 "63 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_64_30 "64 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_65_30 "65 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_66_30 "66 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_67_30 "67 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_68_30 "68 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_69_30 "69 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_70_30 "70 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_71_30 "71 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_72_30 "72 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_73_30 "73 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_74_30 "74 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_75_30 "75 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_76_30 "76 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_77_30 "77 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_78_30 "78 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_79_30 "79 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_80_30 "80 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_81_30 "81 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_82_30 "82 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_83_30 "83 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_84_30 "84 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_85_30 "85 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_86_30 "86 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_87_30 "87 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_88_30 "88 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_89_30 "89 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_90_30 "90 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_91_30 "91 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_92_30 "92 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_93_30 "93 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_94_30 "94 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_95_30 "95 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_96_30 "96 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_97_30 "97 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_98_30 "98 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_99_30 "99 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_100_30 "100 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_101_30 "101 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_102_30 "102 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_103_30 "103 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_104_30 "104 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_105_30 "105 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_106_30 "106 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_107_30 "107 电池单体电压";
CM_ SG_ 2400841310 CSC_Ucell_108_30 "108 电池单体电压";
CM_ SG_ 2400841311 CSC_U_No_31 "CSC号";
CM_ SG_ 2400841311 CSC_Ucell_Frame_Index_31 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841311 CSC_Ucell_58_31 "58 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_59_31 "59 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_60_31 "60 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_61_31 "61 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_62_31 "62 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_63_31 "63 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_64_31 "64 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_65_31 "65 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_66_31 "66 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_67_31 "67 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_68_31 "68 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_69_31 "69 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_70_31 "70 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_71_31 "71 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_72_31 "72 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_73_31 "73 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_74_31 "74 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_75_31 "75 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_76_31 "76 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_77_31 "77 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_78_31 "78 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_79_31 "79 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_80_31 "80 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_81_31 "81 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_82_31 "82 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_83_31 "83 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_84_31 "84 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_85_31 "85 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_86_31 "86 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_87_31 "87 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_88_31 "88 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_89_31 "89 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_90_31 "90 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_91_31 "91 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_92_31 "92 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_93_31 "93 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_94_31 "94 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_95_31 "95 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_96_31 "96 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_97_31 "97 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_98_31 "98 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_99_31 "99 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_100_31 "100 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_101_31 "101 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_102_31 "102 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_103_31 "103 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_104_31 "104 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_105_31 "105 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_106_31 "106 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_107_31 "107 电池单体电压";
CM_ SG_ 2400841311 CSC_Ucell_108_31 "108 电池单体电压";
CM_ SG_ 2400841312 CSC_U_No_32 "CSC号";
CM_ SG_ 2400841312 CSC_Ucell_Frame_Index_32 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841312 CSC_Ucell_58_32 "58 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_59_32 "59 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_60_32 "60 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_61_32 "61 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_62_32 "62 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_63_32 "63 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_64_32 "64 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_65_32 "65 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_66_32 "66 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_67_32 "67 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_68_32 "68 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_69_32 "69 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_70_32 "70 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_71_32 "71 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_72_32 "72 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_73_32 "73 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_74_32 "74 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_75_32 "75 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_76_32 "76 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_77_32 "77 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_78_32 "78 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_79_32 "79 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_80_32 "80 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_81_32 "81 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_82_32 "82 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_83_32 "83 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_84_32 "84 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_85_32 "85 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_86_32 "86 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_87_32 "87 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_88_32 "88 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_89_32 "89 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_90_32 "90 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_91_32 "91 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_92_32 "92 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_93_32 "93 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_94_32 "94 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_95_32 "95 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_96_32 "96 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_97_32 "97 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_98_32 "98 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_99_32 "99 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_100_32 "100 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_101_32 "101 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_102_32 "102 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_103_32 "103 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_104_32 "104 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_105_32 "105 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_106_32 "106 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_107_32 "107 电池单体电压";
CM_ SG_ 2400841312 CSC_Ucell_108_32 "108 电池单体电压";
CM_ SG_ 2400841313 CSC_U_No_33 "CSC号";
CM_ SG_ 2400841313 CSC_Ucell_Frame_Index_33 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841313 CSC_Ucell_58_33 "58 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_59_33 "59 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_60_33 "60 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_61_33 "61 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_62_33 "62 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_63_33 "63 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_64_33 "64 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_65_33 "65 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_66_33 "66 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_67_33 "67 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_68_33 "68 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_69_33 "69 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_70_33 "70 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_71_33 "71 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_72_33 "72 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_73_33 "73 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_74_33 "74 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_75_33 "75 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_76_33 "76 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_77_33 "77 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_78_33 "78 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_79_33 "79 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_80_33 "80 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_81_33 "81 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_82_33 "82 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_83_33 "83 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_84_33 "84 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_85_33 "85 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_86_33 "86 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_87_33 "87 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_88_33 "88 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_89_33 "89 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_90_33 "90 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_91_33 "91 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_92_33 "92 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_93_33 "93 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_94_33 "94 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_95_33 "95 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_96_33 "96 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_97_33 "97 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_98_33 "98 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_99_33 "99 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_100_33 "100 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_101_33 "101 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_102_33 "102 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_103_33 "103 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_104_33 "104 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_105_33 "105 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_106_33 "106 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_107_33 "107 电池单体电压";
CM_ SG_ 2400841313 CSC_Ucell_108_33 "108 电池单体电压";
CM_ SG_ 2400841314 CSC_U_No_34 "CSC号";
CM_ SG_ 2400841314 CSC_Ucell_Frame_Index_34 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841314 CSC_Ucell_58_34 "58 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_59_34 "59 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_60_34 "60 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_61_34 "61 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_62_34 "62 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_63_34 "63 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_64_34 "64 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_65_34 "65 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_66_34 "66 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_67_34 "67 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_68_34 "68 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_69_34 "69 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_70_34 "70 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_71_34 "71 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_72_34 "72 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_73_34 "73 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_74_34 "74 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_75_34 "75 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_76_34 "76 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_77_34 "77 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_78_34 "78 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_79_34 "79 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_80_34 "80 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_81_34 "81 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_82_34 "82 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_83_34 "83 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_84_34 "84 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_85_34 "85 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_86_34 "86 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_87_34 "87 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_88_34 "88 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_89_34 "89 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_90_34 "90 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_91_34 "91 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_92_34 "92 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_93_34 "93 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_94_34 "94 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_95_34 "95 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_96_34 "96 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_97_34 "97 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_98_34 "98 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_99_34 "99 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_100_34 "100 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_101_34 "101 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_102_34 "102 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_103_34 "103 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_104_34 "104 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_105_34 "105 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_106_34 "106 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_107_34 "107 电池单体电压";
CM_ SG_ 2400841314 CSC_Ucell_108_34 "108 电池单体电压";
CM_ SG_ 2400841315 CSC_U_No_35 "CSC号";
CM_ SG_ 2400841315 CSC_Ucell_Frame_Index_35 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841315 CSC_Ucell_58_35 "58 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_59_35 "59 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_60_35 "60 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_61_35 "61 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_62_35 "62 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_63_35 "63 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_64_35 "64 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_65_35 "65 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_66_35 "66 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_67_35 "67 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_68_35 "68 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_69_35 "69 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_70_35 "70 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_71_35 "71 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_72_35 "72 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_73_35 "73 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_74_35 "74 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_75_35 "75 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_76_35 "76 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_77_35 "77 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_78_35 "78 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_79_35 "79 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_80_35 "80 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_81_35 "81 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_82_35 "82 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_83_35 "83 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_84_35 "84 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_85_35 "85 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_86_35 "86 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_87_35 "87 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_88_35 "88 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_89_35 "89 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_90_35 "90 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_91_35 "91 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_92_35 "92 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_93_35 "93 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_94_35 "94 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_95_35 "95 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_96_35 "96 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_97_35 "97 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_98_35 "98 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_99_35 "99 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_100_35 "100 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_101_35 "101 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_102_35 "102 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_103_35 "103 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_104_35 "104 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_105_35 "105 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_106_35 "106 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_107_35 "107 电池单体电压";
CM_ SG_ 2400841315 CSC_Ucell_108_35 "108 电池单体电压";
CM_ SG_ 2400841316 CSC_U_No_36 "CSC号";
CM_ SG_ 2400841316 CSC_Ucell_Frame_Index_36 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841316 CSC_Ucell_58_36 "58 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_59_36 "59 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_60_36 "60 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_61_36 "61 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_62_36 "62 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_63_36 "63 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_64_36 "64 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_65_36 "65 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_66_36 "66 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_67_36 "67 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_68_36 "68 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_69_36 "69 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_70_36 "70 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_71_36 "71 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_72_36 "72 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_73_36 "73 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_74_36 "74 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_75_36 "75 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_76_36 "76 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_77_36 "77 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_78_36 "78 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_79_36 "79 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_80_36 "80 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_81_36 "81 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_82_36 "82 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_83_36 "83 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_84_36 "84 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_85_36 "85 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_86_36 "86 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_87_36 "87 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_88_36 "88 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_89_36 "89 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_90_36 "90 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_91_36 "91 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_92_36 "92 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_93_36 "93 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_94_36 "94 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_95_36 "95 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_96_36 "96 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_97_36 "97 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_98_36 "98 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_99_36 "99 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_100_36 "100 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_101_36 "101 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_102_36 "102 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_103_36 "103 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_104_36 "104 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_105_36 "105 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_106_36 "106 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_107_36 "107 电池单体电压";
CM_ SG_ 2400841316 CSC_Ucell_108_36 "108 电池单体电压";
CM_ SG_ 2400841317 CSC_U_No_37 "CSC号";
CM_ SG_ 2400841317 CSC_Ucell_Frame_Index_37 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841317 CSC_Ucell_58_37 "58 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_59_37 "59 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_60_37 "60 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_61_37 "61 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_62_37 "62 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_63_37 "63 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_64_37 "64 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_65_37 "65 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_66_37 "66 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_67_37 "67 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_68_37 "68 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_69_37 "69 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_70_37 "70 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_71_37 "71 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_72_37 "72 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_73_37 "73 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_74_37 "74 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_75_37 "75 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_76_37 "76 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_77_37 "77 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_78_37 "78 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_79_37 "79 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_80_37 "80 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_81_37 "81 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_82_37 "82 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_83_37 "83 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_84_37 "84 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_85_37 "85 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_86_37 "86 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_87_37 "87 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_88_37 "88 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_89_37 "89 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_90_37 "90 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_91_37 "91 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_92_37 "92 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_93_37 "93 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_94_37 "94 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_95_37 "95 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_96_37 "96 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_97_37 "97 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_98_37 "98 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_99_37 "99 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_100_37 "100 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_101_37 "101 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_102_37 "102 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_103_37 "103 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_104_37 "104 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_105_37 "105 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_106_37 "106 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_107_37 "107 电池单体电压";
CM_ SG_ 2400841317 CSC_Ucell_108_37 "108 电池单体电压";
CM_ SG_ 2400841318 CSC_U_No_38 "CSC号";
CM_ SG_ 2400841318 CSC_Ucell_Frame_Index_38 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841318 CSC_Ucell_58_38 "58 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_59_38 "59 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_60_38 "60 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_61_38 "61 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_62_38 "62 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_63_38 "63 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_64_38 "64 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_65_38 "65 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_66_38 "66 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_67_38 "67 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_68_38 "68 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_69_38 "69 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_70_38 "70 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_71_38 "71 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_72_38 "72 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_73_38 "73 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_74_38 "74 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_75_38 "75 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_76_38 "76 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_77_38 "77 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_78_38 "78 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_79_38 "79 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_80_38 "80 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_81_38 "81 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_82_38 "82 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_83_38 "83 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_84_38 "84 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_85_38 "85 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_86_38 "86 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_87_38 "87 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_88_38 "88 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_89_38 "89 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_90_38 "90 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_91_38 "91 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_92_38 "92 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_93_38 "93 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_94_38 "94 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_95_38 "95 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_96_38 "96 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_97_38 "97 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_98_38 "98 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_99_38 "99 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_100_38 "100 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_101_38 "101 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_102_38 "102 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_103_38 "103 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_104_38 "104 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_105_38 "105 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_106_38 "106 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_107_38 "107 电池单体电压";
CM_ SG_ 2400841318 CSC_Ucell_108_38 "108 电池单体电压";
CM_ SG_ 2400841319 CSC_U_No_39 "CSC号";
CM_ SG_ 2400841319 CSC_Ucell_Frame_Index_39 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841319 CSC_Ucell_58_39 "58 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_59_39 "59 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_60_39 "60 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_61_39 "61 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_62_39 "62 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_63_39 "63 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_64_39 "64 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_65_39 "65 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_66_39 "66 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_67_39 "67 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_68_39 "68 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_69_39 "69 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_70_39 "70 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_71_39 "71 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_72_39 "72 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_73_39 "73 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_74_39 "74 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_75_39 "75 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_76_39 "76 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_77_39 "77 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_78_39 "78 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_79_39 "79 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_80_39 "80 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_81_39 "81 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_82_39 "82 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_83_39 "83 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_84_39 "84 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_85_39 "85 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_86_39 "86 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_87_39 "87 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_88_39 "88 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_89_39 "89 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_90_39 "90 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_91_39 "91 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_92_39 "92 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_93_39 "93 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_94_39 "94 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_95_39 "95 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_96_39 "96 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_97_39 "97 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_98_39 "98 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_99_39 "99 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_100_39 "100 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_101_39 "101 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_102_39 "102 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_103_39 "103 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_104_39 "104 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_105_39 "105 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_106_39 "106 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_107_39 "107 电池单体电压";
CM_ SG_ 2400841319 CSC_Ucell_108_39 "108 电池单体电压";
CM_ SG_ 2400841320 CSC_U_No_40 "CSC号";
CM_ SG_ 2400841320 CSC_Ucell_Frame_Index_40 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400841320 CSC_Ucell_58_40 "58 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_59_40 "59 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_60_40 "60 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_61_40 "61 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_62_40 "62 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_63_40 "63 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_64_40 "64 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_65_40 "65 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_66_40 "66 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_67_40 "67 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_68_40 "68 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_69_40 "69 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_70_40 "70 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_71_40 "71 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_72_40 "72 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_73_40 "73 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_74_40 "74 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_75_40 "75 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_76_40 "76 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_77_40 "77 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_78_40 "78 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_79_40 "79 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_80_40 "80 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_81_40 "81 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_82_40 "82 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_83_40 "83 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_84_40 "84 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_85_40 "85 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_86_40 "86 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_87_40 "87 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_88_40 "88 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_89_40 "89 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_90_40 "90 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_91_40 "91 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_92_40 "92 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_93_40 "93 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_94_40 "94 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_95_40 "95 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_96_40 "96 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_97_40 "97 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_98_40 "98 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_99_40 "99 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_100_40 "100 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_101_40 "101 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_102_40 "102 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_103_40 "103 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_104_40 "104 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_105_40 "105 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_106_40 "106 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_107_40 "107 电池单体电压";
CM_ SG_ 2400841320 CSC_Ucell_108_40 "108 电池单体电压";
VAL_ 2400841299 CSC_U_No_19 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841299 CSC_Ucell_58_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_59_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_60_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_61_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_62_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_63_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_64_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_65_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_66_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_67_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_68_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_69_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_70_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_71_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_72_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_73_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_74_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_75_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_76_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_77_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_78_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_79_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_80_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_81_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_82_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_83_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_84_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_85_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_86_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_87_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_88_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_89_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_90_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_91_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_92_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_93_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_94_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_95_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_96_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_97_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_98_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_99_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_100_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_101_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_102_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_103_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_104_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_105_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_106_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_107_19 65535 "Invalid" ;
VAL_ 2400841299 CSC_Ucell_108_19 65535 "Invalid" ;
VAL_ 2400841300 CSC_U_No_20 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841300 CSC_Ucell_58_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_59_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_60_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_61_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_62_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_63_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_64_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_65_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_66_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_67_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_68_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_69_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_70_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_71_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_72_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_73_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_74_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_75_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_76_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_77_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_78_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_79_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_80_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_81_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_82_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_83_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_84_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_85_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_86_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_87_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_88_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_89_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_90_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_91_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_92_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_93_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_94_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_95_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_96_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_97_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_98_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_99_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_100_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_101_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_102_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_103_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_104_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_105_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_106_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_107_20 65535 "Invalid" ;
VAL_ 2400841300 CSC_Ucell_108_20 65535 "Invalid" ;
VAL_ 2400841301 CSC_U_No_21 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841301 CSC_Ucell_58_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_59_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_60_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_61_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_62_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_63_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_64_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_65_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_66_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_67_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_68_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_69_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_70_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_71_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_72_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_73_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_74_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_75_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_76_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_77_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_78_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_79_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_80_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_81_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_82_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_83_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_84_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_85_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_86_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_87_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_88_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_89_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_90_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_91_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_92_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_93_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_94_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_95_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_96_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_97_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_98_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_99_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_100_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_101_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_102_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_103_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_104_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_105_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_106_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_107_21 65535 "Invalid" ;
VAL_ 2400841301 CSC_Ucell_108_21 65535 "Invalid" ;
VAL_ 2400841302 CSC_U_No_22 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841302 CSC_Ucell_58_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_59_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_60_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_61_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_62_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_63_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_64_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_65_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_66_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_67_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_68_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_69_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_70_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_71_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_72_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_73_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_74_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_75_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_76_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_77_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_78_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_79_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_80_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_81_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_82_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_83_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_84_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_85_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_86_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_87_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_88_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_89_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_90_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_91_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_92_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_93_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_94_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_95_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_96_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_97_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_98_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_99_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_100_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_101_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_102_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_103_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_104_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_105_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_106_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_107_22 65535 "Invalid" ;
VAL_ 2400841302 CSC_Ucell_108_22 65535 "Invalid" ;
VAL_ 2400841303 CSC_U_No_23 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841303 CSC_Ucell_58_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_59_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_60_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_61_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_62_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_63_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_64_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_65_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_66_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_67_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_68_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_69_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_70_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_71_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_72_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_73_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_74_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_75_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_76_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_77_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_78_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_79_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_80_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_81_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_82_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_83_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_84_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_85_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_86_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_87_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_88_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_89_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_90_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_91_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_92_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_93_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_94_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_95_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_96_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_97_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_98_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_99_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_100_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_101_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_102_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_103_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_104_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_105_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_106_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_107_23 65535 "Invalid" ;
VAL_ 2400841303 CSC_Ucell_108_23 65535 "Invalid" ;
VAL_ 2400841304 CSC_U_No_24 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841304 CSC_Ucell_58_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_59_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_60_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_61_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_62_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_63_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_64_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_65_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_66_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_67_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_68_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_69_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_70_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_71_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_72_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_73_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_74_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_75_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_76_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_77_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_78_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_79_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_80_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_81_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_82_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_83_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_84_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_85_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_86_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_87_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_88_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_89_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_90_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_91_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_92_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_93_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_94_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_95_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_96_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_97_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_98_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_99_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_100_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_101_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_102_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_103_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_104_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_105_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_106_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_107_24 65535 "Invalid" ;
VAL_ 2400841304 CSC_Ucell_108_24 65535 "Invalid" ;
VAL_ 2400841305 CSC_U_No_25 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841305 CSC_Ucell_58_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_59_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_60_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_61_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_62_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_63_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_64_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_65_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_66_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_67_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_68_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_69_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_70_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_71_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_72_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_73_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_74_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_75_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_76_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_77_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_78_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_79_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_80_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_81_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_82_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_83_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_84_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_85_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_86_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_87_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_88_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_89_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_90_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_91_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_92_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_93_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_94_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_95_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_96_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_97_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_98_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_99_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_100_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_101_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_102_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_103_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_104_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_105_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_106_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_107_25 65535 "Invalid" ;
VAL_ 2400841305 CSC_Ucell_108_25 65535 "Invalid" ;
VAL_ 2400841306 CSC_U_No_26 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841306 CSC_Ucell_58_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_59_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_60_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_61_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_62_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_63_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_64_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_65_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_66_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_67_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_68_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_69_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_70_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_71_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_72_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_73_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_74_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_75_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_76_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_77_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_78_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_79_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_80_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_81_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_82_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_83_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_84_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_85_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_86_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_87_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_88_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_89_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_90_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_91_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_92_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_93_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_94_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_95_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_96_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_97_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_98_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_99_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_100_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_101_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_102_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_103_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_104_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_105_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_106_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_107_26 65535 "Invalid" ;
VAL_ 2400841306 CSC_Ucell_108_26 65535 "Invalid" ;
VAL_ 2400841307 CSC_U_No_27 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841307 CSC_Ucell_58_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_59_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_60_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_61_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_62_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_63_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_64_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_65_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_66_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_67_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_68_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_69_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_70_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_71_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_72_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_73_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_74_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_75_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_76_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_77_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_78_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_79_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_80_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_81_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_82_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_83_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_84_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_85_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_86_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_87_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_88_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_89_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_90_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_91_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_92_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_93_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_94_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_95_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_96_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_97_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_98_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_99_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_100_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_101_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_102_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_103_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_104_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_105_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_106_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_107_27 65535 "Invalid" ;
VAL_ 2400841307 CSC_Ucell_108_27 65535 "Invalid" ;
VAL_ 2400841308 CSC_U_No_28 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841308 CSC_Ucell_58_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_59_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_60_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_61_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_62_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_63_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_64_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_65_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_66_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_67_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_68_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_69_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_70_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_71_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_72_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_73_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_74_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_75_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_76_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_77_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_78_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_79_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_80_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_81_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_82_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_83_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_84_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_85_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_86_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_87_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_88_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_89_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_90_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_91_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_92_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_93_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_94_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_95_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_96_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_97_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_98_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_99_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_100_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_101_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_102_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_103_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_104_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_105_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_106_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_107_28 65535 "Invalid" ;
VAL_ 2400841308 CSC_Ucell_108_28 65535 "Invalid" ;
VAL_ 2400841309 CSC_U_No_29 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841309 CSC_Ucell_58_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_59_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_60_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_61_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_62_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_63_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_64_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_65_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_66_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_67_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_68_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_69_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_70_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_71_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_72_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_73_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_74_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_75_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_76_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_77_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_78_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_79_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_80_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_81_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_82_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_83_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_84_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_85_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_86_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_87_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_88_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_89_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_90_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_91_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_92_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_93_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_94_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_95_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_96_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_97_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_98_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_99_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_100_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_101_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_102_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_103_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_104_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_105_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_106_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_107_29 65535 "Invalid" ;
VAL_ 2400841309 CSC_Ucell_108_29 65535 "Invalid" ;
VAL_ 2400841310 CSC_U_No_30 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841310 CSC_Ucell_58_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_59_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_60_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_61_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_62_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_63_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_64_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_65_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_66_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_67_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_68_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_69_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_70_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_71_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_72_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_73_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_74_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_75_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_76_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_77_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_78_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_79_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_80_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_81_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_82_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_83_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_84_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_85_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_86_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_87_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_88_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_89_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_90_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_91_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_92_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_93_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_94_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_95_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_96_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_97_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_98_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_99_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_100_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_101_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_102_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_103_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_104_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_105_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_106_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_107_30 65535 "Invalid" ;
VAL_ 2400841310 CSC_Ucell_108_30 65535 "Invalid" ;
VAL_ 2400841311 CSC_U_No_31 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841311 CSC_Ucell_58_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_59_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_60_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_61_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_62_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_63_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_64_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_65_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_66_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_67_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_68_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_69_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_70_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_71_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_72_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_73_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_74_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_75_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_76_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_77_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_78_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_79_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_80_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_81_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_82_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_83_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_84_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_85_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_86_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_87_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_88_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_89_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_90_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_91_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_92_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_93_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_94_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_95_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_96_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_97_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_98_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_99_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_100_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_101_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_102_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_103_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_104_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_105_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_106_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_107_31 65535 "Invalid" ;
VAL_ 2400841311 CSC_Ucell_108_31 65535 "Invalid" ;
VAL_ 2400841312 CSC_U_No_32 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841312 CSC_Ucell_58_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_59_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_60_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_61_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_62_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_63_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_64_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_65_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_66_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_67_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_68_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_69_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_70_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_71_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_72_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_73_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_74_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_75_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_76_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_77_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_78_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_79_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_80_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_81_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_82_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_83_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_84_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_85_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_86_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_87_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_88_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_89_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_90_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_91_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_92_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_93_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_94_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_95_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_96_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_97_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_98_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_99_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_100_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_101_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_102_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_103_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_104_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_105_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_106_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_107_32 65535 "Invalid" ;
VAL_ 2400841312 CSC_Ucell_108_32 65535 "Invalid" ;
VAL_ 2400841313 CSC_U_No_33 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841313 CSC_Ucell_58_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_59_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_60_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_61_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_62_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_63_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_64_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_65_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_66_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_67_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_68_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_69_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_70_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_71_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_72_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_73_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_74_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_75_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_76_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_77_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_78_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_79_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_80_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_81_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_82_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_83_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_84_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_85_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_86_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_87_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_88_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_89_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_90_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_91_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_92_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_93_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_94_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_95_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_96_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_97_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_98_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_99_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_100_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_101_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_102_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_103_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_104_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_105_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_106_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_107_33 65535 "Invalid" ;
VAL_ 2400841313 CSC_Ucell_108_33 65535 "Invalid" ;
VAL_ 2400841314 CSC_U_No_34 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841314 CSC_Ucell_58_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_59_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_60_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_61_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_62_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_63_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_64_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_65_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_66_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_67_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_68_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_69_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_70_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_71_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_72_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_73_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_74_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_75_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_76_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_77_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_78_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_79_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_80_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_81_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_82_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_83_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_84_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_85_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_86_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_87_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_88_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_89_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_90_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_91_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_92_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_93_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_94_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_95_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_96_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_97_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_98_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_99_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_100_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_101_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_102_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_103_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_104_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_105_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_106_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_107_34 65535 "Invalid" ;
VAL_ 2400841314 CSC_Ucell_108_34 65535 "Invalid" ;
VAL_ 2400841315 CSC_U_No_35 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841315 CSC_Ucell_58_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_59_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_60_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_61_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_62_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_63_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_64_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_65_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_66_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_67_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_68_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_69_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_70_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_71_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_72_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_73_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_74_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_75_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_76_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_77_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_78_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_79_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_80_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_81_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_82_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_83_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_84_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_85_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_86_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_87_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_88_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_89_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_90_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_91_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_92_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_93_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_94_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_95_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_96_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_97_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_98_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_99_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_100_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_101_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_102_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_103_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_104_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_105_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_106_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_107_35 65535 "Invalid" ;
VAL_ 2400841315 CSC_Ucell_108_35 65535 "Invalid" ;
VAL_ 2400841316 CSC_U_No_36 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841316 CSC_Ucell_58_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_59_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_60_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_61_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_62_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_63_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_64_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_65_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_66_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_67_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_68_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_69_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_70_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_71_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_72_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_73_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_74_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_75_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_76_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_77_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_78_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_79_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_80_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_81_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_82_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_83_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_84_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_85_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_86_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_87_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_88_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_89_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_90_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_91_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_92_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_93_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_94_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_95_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_96_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_97_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_98_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_99_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_100_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_101_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_102_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_103_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_104_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_105_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_106_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_107_36 65535 "Invalid" ;
VAL_ 2400841316 CSC_Ucell_108_36 65535 "Invalid" ;
VAL_ 2400841317 CSC_U_No_37 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841317 CSC_Ucell_58_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_59_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_60_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_61_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_62_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_63_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_64_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_65_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_66_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_67_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_68_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_69_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_70_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_71_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_72_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_73_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_74_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_75_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_76_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_77_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_78_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_79_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_80_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_81_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_82_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_83_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_84_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_85_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_86_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_87_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_88_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_89_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_90_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_91_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_92_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_93_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_94_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_95_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_96_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_97_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_98_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_99_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_100_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_101_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_102_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_103_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_104_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_105_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_106_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_107_37 65535 "Invalid" ;
VAL_ 2400841317 CSC_Ucell_108_37 65535 "Invalid" ;
VAL_ 2400841318 CSC_U_No_38 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841318 CSC_Ucell_58_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_59_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_60_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_61_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_62_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_63_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_64_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_65_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_66_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_67_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_68_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_69_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_70_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_71_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_72_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_73_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_74_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_75_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_76_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_77_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_78_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_79_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_80_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_81_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_82_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_83_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_84_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_85_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_86_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_87_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_88_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_89_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_90_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_91_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_92_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_93_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_94_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_95_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_96_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_97_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_98_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_99_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_100_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_101_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_102_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_103_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_104_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_105_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_106_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_107_38 65535 "Invalid" ;
VAL_ 2400841318 CSC_Ucell_108_38 65535 "Invalid" ;
VAL_ 2400841319 CSC_U_No_39 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841319 CSC_Ucell_58_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_59_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_60_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_61_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_62_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_63_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_64_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_65_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_66_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_67_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_68_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_69_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_70_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_71_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_72_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_73_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_74_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_75_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_76_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_77_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_78_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_79_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_80_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_81_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_82_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_83_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_84_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_85_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_86_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_87_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_88_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_89_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_90_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_91_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_92_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_93_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_94_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_95_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_96_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_97_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_98_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_99_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_100_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_101_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_102_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_103_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_104_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_105_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_106_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_107_39 65535 "Invalid" ;
VAL_ 2400841319 CSC_Ucell_108_39 65535 "Invalid" ;
VAL_ 2400841320 CSC_U_No_40 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400841320 CSC_Ucell_58_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_59_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_60_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_61_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_62_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_63_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_64_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_65_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_66_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_67_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_68_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_69_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_70_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_71_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_72_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_73_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_74_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_75_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_76_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_77_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_78_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_79_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_80_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_81_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_82_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_83_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_84_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_85_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_86_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_87_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_88_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_89_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_90_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_91_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_92_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_93_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_94_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_95_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_96_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_97_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_98_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_99_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_100_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_101_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_102_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_103_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_104_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_105_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_106_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_107_40 65535 "Invalid" ;
VAL_ 2400841320 CSC_Ucell_108_40 65535 "Invalid" ;
