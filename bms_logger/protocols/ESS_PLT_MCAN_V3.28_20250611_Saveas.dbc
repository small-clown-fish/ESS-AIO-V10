VERSION ""

NS_ :

BS_:

BU_: MBMU PC SBMU IMM ETH DCDC LEMS

BO_ 2400382532 S2P_Detail_Tcell1__04: 8 SBMU
 SG_ CSC_T_No_04 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_04 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_04 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_04 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_04 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_04 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_04 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_04 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_04 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_04 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_04 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_04 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_04 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_04 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_04 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_04 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_04 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_04 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_04 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_04 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_04 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_04 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_04 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_04 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_04 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_04 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_04 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_04 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_04 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_04 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_04 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_04 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_04 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_04 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_04 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_04 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_04 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_04 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_04 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_04 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_04 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_04 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_04 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_04 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_04 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_04 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_04 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_04 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_04 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_04 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_04 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_04 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_04 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_04 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_04 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_04 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_04 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_04 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_04 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_04 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_04 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_04 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_04 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_04 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_04 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_04 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_04 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_04 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_04 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_04 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_04 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_04 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_04 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_04 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382533 S2P_Detail_Tcell1__05: 8 SBMU
 SG_ CSC_T_No_05 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_05 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_05 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_05 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_05 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_05 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_05 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_05 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_05 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_05 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_05 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_05 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_05 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_05 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_05 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_05 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_05 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_05 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_05 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_05 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_05 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_05 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_05 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_05 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_05 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_05 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_05 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_05 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_05 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_05 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_05 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_05 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_05 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_05 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_05 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_05 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_05 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_05 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_05 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_05 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_05 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_05 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_05 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_05 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_05 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_05 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_05 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_05 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_05 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_05 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_05 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_05 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_05 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_05 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_05 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_05 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_05 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_05 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_05 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_05 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_05 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_05 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_05 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_05 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_05 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_05 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_05 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_05 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_05 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_05 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_05 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_05 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_05 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_05 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382534 S2P_Detail_Tcell1__06: 8 SBMU
 SG_ CSC_T_No_06 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_06 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_06 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_06 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_06 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_06 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_06 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_06 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_06 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_06 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_06 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_06 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_06 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_06 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_06 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_06 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_06 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_06 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_06 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_06 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_06 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_06 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_06 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_06 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_06 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_06 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_06 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_06 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_06 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_06 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_06 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_06 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_06 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_06 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_06 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_06 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_06 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_06 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_06 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_06 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_06 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_06 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_06 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_06 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_06 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_06 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_06 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_06 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_06 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_06 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_06 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_06 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_06 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_06 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_06 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_06 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_06 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_06 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_06 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_06 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_06 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_06 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_06 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_06 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_06 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_06 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_06 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_06 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_06 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_06 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_06 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_06 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_06 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_06 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382535 S2P_Detail_Tcell1__07: 8 SBMU
 SG_ CSC_T_No_07 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_07 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_07 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_07 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_07 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_07 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_07 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_07 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_07 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_07 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_07 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_07 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_07 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_07 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_07 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_07 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_07 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_07 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_07 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_07 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_07 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_07 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_07 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_07 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_07 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_07 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_07 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_07 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_07 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_07 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_07 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_07 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_07 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_07 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_07 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_07 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_07 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_07 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_07 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_07 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_07 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_07 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_07 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_07 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_07 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_07 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_07 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_07 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_07 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_07 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_07 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_07 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_07 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_07 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_07 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_07 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_07 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_07 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_07 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_07 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_07 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_07 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_07 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_07 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_07 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_07 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_07 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_07 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_07 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_07 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_07 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_07 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_07 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_07 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382536 S2P_Detail_Tcell1__08: 8 SBMU
 SG_ CSC_T_No_08 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_08 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_08 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_08 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_08 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_08 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_08 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_08 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_08 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_08 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_08 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_08 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_08 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_08 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_08 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_08 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_08 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_08 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_08 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_08 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_08 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_08 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_08 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_08 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_08 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_08 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_08 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_08 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_08 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_08 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_08 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_08 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_08 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_08 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_08 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_08 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_08 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_08 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_08 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_08 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_08 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_08 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_08 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_08 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_08 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_08 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_08 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_08 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_08 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_08 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_08 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_08 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_08 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_08 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_08 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_08 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_08 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_08 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_08 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_08 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_08 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_08 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_08 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_08 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_08 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_08 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_08 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_08 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_08 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_08 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_08 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_08 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_08 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_08 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382537 S2P_Detail_Tcell1__09: 8 SBMU
 SG_ CSC_T_No_09 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_09 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_09 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_09 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_09 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_09 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_09 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_09 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_09 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_09 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_09 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_09 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_09 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_09 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_09 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_09 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_09 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_09 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_09 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_09 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_09 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_09 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_09 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_09 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_09 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_09 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_09 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_09 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_09 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_09 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_09 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_09 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_09 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_09 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_09 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_09 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_09 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_09 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_09 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_09 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_09 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_09 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_09 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_09 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_09 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_09 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_09 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_09 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_09 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_09 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_09 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_09 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_09 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_09 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_09 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_09 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_09 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_09 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_09 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_09 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_09 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_09 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_09 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_09 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_09 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_09 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_09 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_09 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_09 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_09 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_09 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_09 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_09 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_09 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382538 S2P_Detail_Tcell1__10: 8 SBMU
 SG_ CSC_T_No_10 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_10 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_10 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_10 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_10 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_10 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_10 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_10 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_10 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_10 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_10 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_10 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_10 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_10 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_10 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_10 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_10 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_10 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_10 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_10 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_10 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_10 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_10 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_10 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_10 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_10 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_10 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_10 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_10 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_10 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_10 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_10 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_10 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_10 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_10 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_10 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_10 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_10 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_10 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_10 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_10 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_10 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_10 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_10 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_10 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_10 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_10 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_10 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_10 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_10 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_10 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_10 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_10 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_10 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_10 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_10 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_10 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_10 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_10 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_10 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_10 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_10 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_10 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_10 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_10 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_10 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_10 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_10 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_10 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_10 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_10 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_10 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_10 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_10 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382539 S2P_Detail_Tcell1__11: 8 SBMU
 SG_ CSC_T_No_11 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_11 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_11 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_11 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_11 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_11 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_11 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_11 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_11 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_11 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_11 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_11 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_11 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_11 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_11 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_11 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_11 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_11 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_11 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_11 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_11 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_11 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_11 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_11 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_11 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_11 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_11 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_11 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_11 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_11 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_11 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_11 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_11 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_11 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_11 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_11 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_11 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_11 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_11 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_11 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_11 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_11 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_11 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_11 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_11 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_11 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_11 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_11 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_11 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_11 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_11 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_11 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_11 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_11 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_11 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_11 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_11 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_11 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_11 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_11 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_11 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_11 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_11 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_11 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_11 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_11 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_11 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_11 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_11 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_11 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_11 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_11 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_11 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_11 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382540 S2P_Detail_Tcell1__12: 8 SBMU
 SG_ CSC_T_No_12 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_12 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_12 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_12 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_12 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_12 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_12 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_12 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_12 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_12 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_12 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_12 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_12 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_12 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_12 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_12 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_12 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_12 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_12 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_12 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_12 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_12 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_12 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_12 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_12 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_12 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_12 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_12 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_12 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_12 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_12 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_12 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_12 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_12 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_12 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_12 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_12 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_12 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_12 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_12 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_12 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_12 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_12 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_12 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_12 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_12 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_12 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_12 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_12 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_12 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_12 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_12 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_12 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_12 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_12 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_12 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_12 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_12 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_12 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_12 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_12 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_12 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_12 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_12 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_12 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_12 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_12 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_12 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_12 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_12 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_12 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_12 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_12 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_12 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382541 S2P_Detail_Tcell1__13: 8 SBMU
 SG_ CSC_T_No_13 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_13 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_13 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_13 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_13 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_13 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_13 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_13 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_13 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_13 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_13 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_13 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_13 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_13 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_13 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_13 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_13 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_13 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_13 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_13 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_13 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_13 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_13 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_13 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_13 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_13 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_13 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_13 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_13 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_13 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_13 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_13 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_13 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_13 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_13 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_13 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_13 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_13 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_13 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_13 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_13 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_13 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_13 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_13 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_13 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_13 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_13 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_13 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_13 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_13 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_13 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_13 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_13 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_13 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_13 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_13 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_13 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_13 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_13 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_13 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_13 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_13 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_13 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_13 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_13 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_13 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_13 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_13 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_13 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_13 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_13 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_13 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_13 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_13 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382542 S2P_Detail_Tcell1__14: 8 SBMU
 SG_ CSC_T_No_14 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_14 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_14 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_14 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_14 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_14 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_14 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_14 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_14 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_14 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_14 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_14 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_14 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_14 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_14 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_14 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_14 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_14 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_14 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_14 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_14 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_14 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_14 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_14 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_14 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_14 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_14 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_14 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_14 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_14 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_14 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_14 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_14 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_14 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_14 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_14 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_14 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_14 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_14 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_14 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_14 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_14 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_14 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_14 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_14 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_14 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_14 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_14 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_14 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_14 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_14 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_14 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_14 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_14 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_14 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_14 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_14 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_14 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_14 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_14 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_14 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_14 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_14 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_14 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_14 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_14 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_14 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_14 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_14 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_14 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_14 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_14 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_14 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_14 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382543 S2P_Detail_Tcell1__15: 8 SBMU
 SG_ CSC_T_No_15 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_15 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_15 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_15 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_15 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_15 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_15 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_15 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_15 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_15 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_15 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_15 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_15 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_15 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_15 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_15 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_15 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_15 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_15 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_15 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_15 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_15 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_15 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_15 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_15 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_15 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_15 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_15 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_15 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_15 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_15 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_15 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_15 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_15 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_15 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_15 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_15 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_15 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_15 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_15 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_15 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_15 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_15 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_15 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_15 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_15 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_15 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_15 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_15 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_15 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_15 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_15 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_15 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_15 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_15 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_15 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_15 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_15 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_15 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_15 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_15 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_15 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_15 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_15 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_15 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_15 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_15 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_15 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_15 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_15 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_15 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_15 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_15 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_15 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382544 S2P_Detail_Tcell1__16: 8 SBMU
 SG_ CSC_T_No_16 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_16 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_16 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_16 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_16 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_16 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_16 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_16 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_16 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_16 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_16 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_16 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_16 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_16 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_16 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_16 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_16 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_16 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_16 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_16 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_16 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_16 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_16 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_16 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_16 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_16 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_16 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_16 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_16 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_16 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_16 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_16 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_16 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_16 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_16 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_16 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_16 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_16 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_16 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_16 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_16 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_16 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_16 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_16 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_16 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_16 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_16 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_16 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_16 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_16 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_16 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_16 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_16 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_16 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_16 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_16 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_16 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_16 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_16 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_16 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_16 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_16 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_16 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_16 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_16 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_16 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_16 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_16 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_16 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_16 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_16 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_16 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_16 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_16 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382545 S2P_Detail_Tcell1__17: 8 SBMU
 SG_ CSC_T_No_17 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_17 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_17 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_17 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_17 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_17 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_17 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_17 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_17 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_17 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_17 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_17 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_17 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_17 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_17 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_17 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_17 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_17 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_17 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_17 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_17 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_17 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_17 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_17 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_17 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_17 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_17 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_17 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_17 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_17 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_17 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_17 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_17 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_17 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_17 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_17 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_17 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_17 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_17 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_17 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_17 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_17 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_17 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_17 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_17 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_17 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_17 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_17 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_17 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_17 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_17 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_17 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_17 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_17 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_17 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_17 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_17 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_17 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_17 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_17 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_17 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_17 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_17 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_17 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_17 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_17 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_17 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_17 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_17 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_17 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_17 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_17 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_17 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_17 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382546 S2P_Detail_Tcell1__18: 8 SBMU
 SG_ CSC_T_No_18 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_18 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_18 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_18 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_18 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_18 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_18 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_18 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_18 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_18 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_18 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_18 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_18 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_18 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_18 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_18 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_18 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_18 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_18 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_18 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_18 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_18 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_18 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_18 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_18 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_18 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_18 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_18 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_18 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_18 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_18 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_18 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_18 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_18 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_18 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_18 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_18 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_18 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_18 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_18 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_18 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_18 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_18 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_18 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_18 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_18 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_18 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_18 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_18 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_18 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_18 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_18 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_18 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_18 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_18 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_18 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_18 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_18 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_18 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_18 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_18 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_18 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_18 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_18 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_18 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_18 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_18 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_18 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_18 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_18 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_18 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_18 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_18 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_18 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382547 S2P_Detail_Tcell1__19: 8 SBMU
 SG_ CSC_T_No_19 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_19 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_19 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_19 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_19 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_19 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_19 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_19 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_19 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_19 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_19 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_19 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_19 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_19 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_19 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_19 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_19 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_19 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_19 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_19 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_19 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_19 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_19 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_19 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_19 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_19 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_19 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_19 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_19 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_19 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_19 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_19 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_19 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_19 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_19 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_19 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_19 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_19 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_19 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_19 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_19 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_19 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_19 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_19 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_19 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_19 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_19 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_19 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_19 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_19 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_19 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_19 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_19 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_19 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_19 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_19 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_19 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_19 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_19 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_19 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_19 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_19 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_19 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_19 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_19 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_19 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_19 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_19 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_19 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_19 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_19 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_19 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_19 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_19 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382548 S2P_Detail_Tcell1__20: 8 SBMU
 SG_ CSC_T_No_20 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_20 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_20 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_20 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_20 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_20 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_20 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_20 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_20 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_20 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_20 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_20 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_20 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_20 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_20 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_20 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_20 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_20 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_20 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_20 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_20 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_20 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_20 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_20 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_20 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_20 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_20 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_20 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_20 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_20 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_20 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_20 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_20 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_20 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_20 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_20 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_20 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_20 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_20 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_20 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_20 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_20 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_20 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_20 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_20 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_20 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_20 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_20 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_20 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_20 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_20 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_20 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_20 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_20 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_20 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_20 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_20 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_20 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_20 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_20 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_20 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_20 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_20 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_20 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_20 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_20 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_20 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_20 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_20 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_20 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_20 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_20 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_20 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_20 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

CM_ SG_ 2400382532 CSC_T_No_04 "CSC号";
CM_ SG_ 2400382532 CSC_Tcell_Frame_Index_04 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382532 CSC_Tcell_01_04 "温度01";
CM_ SG_ 2400382532 CSC_Tcell_02_04 "温度02";
CM_ SG_ 2400382532 CSC_Tcell_03_04 "温度03";
CM_ SG_ 2400382532 CSC_Tcell_04_04 "温度04";
CM_ SG_ 2400382532 CSC_Tcell_05_04 "温度05";
CM_ SG_ 2400382532 CSC_Tcell_06_04 "温度06";
CM_ SG_ 2400382532 CSC_Tcell_07_04 "温度07";
CM_ SG_ 2400382532 CSC_Tcell_08_04 "温度08";
CM_ SG_ 2400382532 CSC_Tcell_09_04 "温度09";
CM_ SG_ 2400382532 CSC_Tcell_10_04 "温度10";
CM_ SG_ 2400382532 CSC_Tcell_11_04 "温度11";
CM_ SG_ 2400382532 CSC_Tcell_12_04 "温度12";
CM_ SG_ 2400382532 CSC_Tcell_13_04 "温度13";
CM_ SG_ 2400382532 CSC_Tcell_14_04 "温度14";
CM_ SG_ 2400382532 CSC_Tcell_15_04 "温度15";
CM_ SG_ 2400382532 CSC_Tcell_16_04 "温度16";
CM_ SG_ 2400382532 CSC_Tcell_17_04 "温度17";
CM_ SG_ 2400382532 CSC_Tcell_18_04 "温度18";
CM_ SG_ 2400382532 CSC_Tcell_19_04 "温度19";
CM_ SG_ 2400382532 CSC_Tcell_20_04 "温度20";
CM_ SG_ 2400382532 CSC_Tcell_21_04 "温度21";
CM_ SG_ 2400382532 CSC_Tcell_22_04 "温度22";
CM_ SG_ 2400382532 CSC_Tcell_23_04 "温度23";
CM_ SG_ 2400382532 CSC_Tcell_24_04 "温度24";
CM_ SG_ 2400382532 CSC_Tcell_25_04 "温度25";
CM_ SG_ 2400382532 CSC_Tcell_26_04 "温度26";
CM_ SG_ 2400382532 CSC_Tcell_27_04 "温度27";
CM_ SG_ 2400382532 CSC_Tcell_28_04 "温度28";
CM_ SG_ 2400382532 CSC_Tcell_29_04 "温度29";
CM_ SG_ 2400382532 CSC_Tcell_30_04 "温度30";
CM_ SG_ 2400382532 CSC_Tcell_31_04 "温度31";
CM_ SG_ 2400382532 CSC_Tcell_32_04 "温度32";
CM_ SG_ 2400382532 CSC_Tcell_33_04 "温度33";
CM_ SG_ 2400382532 CSC_Tcell_34_04 "温度34";
CM_ SG_ 2400382532 CSC_Tcell_35_04 "温度35";
CM_ SG_ 2400382532 CSC_Tcell_36_04 "温度36";
CM_ SG_ 2400382532 CSC_Tcell_37_04 "温度37";
CM_ SG_ 2400382532 CSC_Tcell_38_04 "温度38";
CM_ SG_ 2400382532 CSC_Tcell_39_04 "温度39";
CM_ SG_ 2400382532 CSC_Tcell_40_04 "温度40";
CM_ SG_ 2400382532 CSC_Tcell_41_04 "温度41";
CM_ SG_ 2400382532 CSC_Tcell_42_04 "温度42";
CM_ SG_ 2400382532 CSC_Tcell_43_04 "温度43";
CM_ SG_ 2400382532 CSC_Tcell_44_04 "温度44";
CM_ SG_ 2400382532 CSC_Tcell_45_04 "温度45";
CM_ SG_ 2400382532 CSC_Tcell_46_04 "温度46";
CM_ SG_ 2400382532 CSC_Tcell_47_04 "温度47";
CM_ SG_ 2400382532 CSC_Tcell_48_04 "温度48";
CM_ SG_ 2400382532 CSC_Tcell_49_04 "温度49";
CM_ SG_ 2400382532 CSC_Tcell_50_04 "温度50";
CM_ SG_ 2400382532 CSC_Tcell_51_04 "温度51";
CM_ SG_ 2400382532 CSC_Tcell_52_04 "温度52";
CM_ SG_ 2400382532 CSC_Tcell_53_04 "温度53";
CM_ SG_ 2400382532 CSC_Tcell_54_04 "温度54";
CM_ SG_ 2400382532 CSC_Tcell_55_04 "温度55";
CM_ SG_ 2400382532 CSC_Tcell_56_04 "温度56";
CM_ SG_ 2400382532 CSC_Tcell_57_04 "温度57";
CM_ SG_ 2400382532 CSC_Tcell_58_04 "温度58";
CM_ SG_ 2400382532 CSC_Tcell_59_04 "温度59";
CM_ SG_ 2400382532 CSC_Tcell_60_04 "温度60";
CM_ SG_ 2400382532 CSC_Tcell_61_04 "温度61";
CM_ SG_ 2400382532 CSC_Tcell_62_04 "温度62";
CM_ SG_ 2400382532 CSC_Tcell_63_04 "温度63";
CM_ SG_ 2400382532 CSC_Tcell_64_04 "温度64";
CM_ SG_ 2400382532 CSC_Tcell_65_04 "温度65";
CM_ SG_ 2400382532 CSC_Tcell_66_04 "温度66";
CM_ SG_ 2400382532 CSC_Tcell_67_04 "温度67";
CM_ SG_ 2400382532 CSC_Tcell_68_04 "温度68";
CM_ SG_ 2400382532 CSC_Tcell_69_04 "温度69";
CM_ SG_ 2400382532 CSC_Tcell_70_04 "温度70";
CM_ SG_ 2400382532 CSC_Tcell_71_04 "温度71";
CM_ SG_ 2400382532 CSC_Tcell_72_04 "温度72";
CM_ SG_ 2400382533 CSC_T_No_05 "CSC号";
CM_ SG_ 2400382533 CSC_Tcell_Frame_Index_05 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382533 CSC_Tcell_01_05 "温度01";
CM_ SG_ 2400382533 CSC_Tcell_02_05 "温度02";
CM_ SG_ 2400382533 CSC_Tcell_03_05 "温度03";
CM_ SG_ 2400382533 CSC_Tcell_04_05 "温度04";
CM_ SG_ 2400382533 CSC_Tcell_05_05 "温度05";
CM_ SG_ 2400382533 CSC_Tcell_06_05 "温度06";
CM_ SG_ 2400382533 CSC_Tcell_07_05 "温度07";
CM_ SG_ 2400382533 CSC_Tcell_08_05 "温度08";
CM_ SG_ 2400382533 CSC_Tcell_09_05 "温度09";
CM_ SG_ 2400382533 CSC_Tcell_10_05 "温度10";
CM_ SG_ 2400382533 CSC_Tcell_11_05 "温度11";
CM_ SG_ 2400382533 CSC_Tcell_12_05 "温度12";
CM_ SG_ 2400382533 CSC_Tcell_13_05 "温度13";
CM_ SG_ 2400382533 CSC_Tcell_14_05 "温度14";
CM_ SG_ 2400382533 CSC_Tcell_15_05 "温度15";
CM_ SG_ 2400382533 CSC_Tcell_16_05 "温度16";
CM_ SG_ 2400382533 CSC_Tcell_17_05 "温度17";
CM_ SG_ 2400382533 CSC_Tcell_18_05 "温度18";
CM_ SG_ 2400382533 CSC_Tcell_19_05 "温度19";
CM_ SG_ 2400382533 CSC_Tcell_20_05 "温度20";
CM_ SG_ 2400382533 CSC_Tcell_21_05 "温度21";
CM_ SG_ 2400382533 CSC_Tcell_22_05 "温度22";
CM_ SG_ 2400382533 CSC_Tcell_23_05 "温度23";
CM_ SG_ 2400382533 CSC_Tcell_24_05 "温度24";
CM_ SG_ 2400382533 CSC_Tcell_25_05 "温度25";
CM_ SG_ 2400382533 CSC_Tcell_26_05 "温度26";
CM_ SG_ 2400382533 CSC_Tcell_27_05 "温度27";
CM_ SG_ 2400382533 CSC_Tcell_28_05 "温度28";
CM_ SG_ 2400382533 CSC_Tcell_29_05 "温度29";
CM_ SG_ 2400382533 CSC_Tcell_30_05 "温度30";
CM_ SG_ 2400382533 CSC_Tcell_31_05 "温度31";
CM_ SG_ 2400382533 CSC_Tcell_32_05 "温度32";
CM_ SG_ 2400382533 CSC_Tcell_33_05 "温度33";
CM_ SG_ 2400382533 CSC_Tcell_34_05 "温度34";
CM_ SG_ 2400382533 CSC_Tcell_35_05 "温度35";
CM_ SG_ 2400382533 CSC_Tcell_36_05 "温度36";
CM_ SG_ 2400382533 CSC_Tcell_37_05 "温度37";
CM_ SG_ 2400382533 CSC_Tcell_38_05 "温度38";
CM_ SG_ 2400382533 CSC_Tcell_39_05 "温度39";
CM_ SG_ 2400382533 CSC_Tcell_40_05 "温度40";
CM_ SG_ 2400382533 CSC_Tcell_41_05 "温度41";
CM_ SG_ 2400382533 CSC_Tcell_42_05 "温度42";
CM_ SG_ 2400382533 CSC_Tcell_43_05 "温度43";
CM_ SG_ 2400382533 CSC_Tcell_44_05 "温度44";
CM_ SG_ 2400382533 CSC_Tcell_45_05 "温度45";
CM_ SG_ 2400382533 CSC_Tcell_46_05 "温度46";
CM_ SG_ 2400382533 CSC_Tcell_47_05 "温度47";
CM_ SG_ 2400382533 CSC_Tcell_48_05 "温度48";
CM_ SG_ 2400382533 CSC_Tcell_49_05 "温度49";
CM_ SG_ 2400382533 CSC_Tcell_50_05 "温度50";
CM_ SG_ 2400382533 CSC_Tcell_51_05 "温度51";
CM_ SG_ 2400382533 CSC_Tcell_52_05 "温度52";
CM_ SG_ 2400382533 CSC_Tcell_53_05 "温度53";
CM_ SG_ 2400382533 CSC_Tcell_54_05 "温度54";
CM_ SG_ 2400382533 CSC_Tcell_55_05 "温度55";
CM_ SG_ 2400382533 CSC_Tcell_56_05 "温度56";
CM_ SG_ 2400382533 CSC_Tcell_57_05 "温度57";
CM_ SG_ 2400382533 CSC_Tcell_58_05 "温度58";
CM_ SG_ 2400382533 CSC_Tcell_59_05 "温度59";
CM_ SG_ 2400382533 CSC_Tcell_60_05 "温度60";
CM_ SG_ 2400382533 CSC_Tcell_61_05 "温度61";
CM_ SG_ 2400382533 CSC_Tcell_62_05 "温度62";
CM_ SG_ 2400382533 CSC_Tcell_63_05 "温度63";
CM_ SG_ 2400382533 CSC_Tcell_64_05 "温度64";
CM_ SG_ 2400382533 CSC_Tcell_65_05 "温度65";
CM_ SG_ 2400382533 CSC_Tcell_66_05 "温度66";
CM_ SG_ 2400382533 CSC_Tcell_67_05 "温度67";
CM_ SG_ 2400382533 CSC_Tcell_68_05 "温度68";
CM_ SG_ 2400382533 CSC_Tcell_69_05 "温度69";
CM_ SG_ 2400382533 CSC_Tcell_70_05 "温度70";
CM_ SG_ 2400382533 CSC_Tcell_71_05 "温度71";
CM_ SG_ 2400382533 CSC_Tcell_72_05 "温度72";
CM_ SG_ 2400382534 CSC_T_No_06 "CSC号";
CM_ SG_ 2400382534 CSC_Tcell_Frame_Index_06 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382534 CSC_Tcell_01_06 "温度01";
CM_ SG_ 2400382534 CSC_Tcell_02_06 "温度02";
CM_ SG_ 2400382534 CSC_Tcell_03_06 "温度03";
CM_ SG_ 2400382534 CSC_Tcell_04_06 "温度04";
CM_ SG_ 2400382534 CSC_Tcell_05_06 "温度05";
CM_ SG_ 2400382534 CSC_Tcell_06_06 "温度06";
CM_ SG_ 2400382534 CSC_Tcell_07_06 "温度07";
CM_ SG_ 2400382534 CSC_Tcell_08_06 "温度08";
CM_ SG_ 2400382534 CSC_Tcell_09_06 "温度09";
CM_ SG_ 2400382534 CSC_Tcell_10_06 "温度10";
CM_ SG_ 2400382534 CSC_Tcell_11_06 "温度11";
CM_ SG_ 2400382534 CSC_Tcell_12_06 "温度12";
CM_ SG_ 2400382534 CSC_Tcell_13_06 "温度13";
CM_ SG_ 2400382534 CSC_Tcell_14_06 "温度14";
CM_ SG_ 2400382534 CSC_Tcell_15_06 "温度15";
CM_ SG_ 2400382534 CSC_Tcell_16_06 "温度16";
CM_ SG_ 2400382534 CSC_Tcell_17_06 "温度17";
CM_ SG_ 2400382534 CSC_Tcell_18_06 "温度18";
CM_ SG_ 2400382534 CSC_Tcell_19_06 "温度19";
CM_ SG_ 2400382534 CSC_Tcell_20_06 "温度20";
CM_ SG_ 2400382534 CSC_Tcell_21_06 "温度21";
CM_ SG_ 2400382534 CSC_Tcell_22_06 "温度22";
CM_ SG_ 2400382534 CSC_Tcell_23_06 "温度23";
CM_ SG_ 2400382534 CSC_Tcell_24_06 "温度24";
CM_ SG_ 2400382534 CSC_Tcell_25_06 "温度25";
CM_ SG_ 2400382534 CSC_Tcell_26_06 "温度26";
CM_ SG_ 2400382534 CSC_Tcell_27_06 "温度27";
CM_ SG_ 2400382534 CSC_Tcell_28_06 "温度28";
CM_ SG_ 2400382534 CSC_Tcell_29_06 "温度29";
CM_ SG_ 2400382534 CSC_Tcell_30_06 "温度30";
CM_ SG_ 2400382534 CSC_Tcell_31_06 "温度31";
CM_ SG_ 2400382534 CSC_Tcell_32_06 "温度32";
CM_ SG_ 2400382534 CSC_Tcell_33_06 "温度33";
CM_ SG_ 2400382534 CSC_Tcell_34_06 "温度34";
CM_ SG_ 2400382534 CSC_Tcell_35_06 "温度35";
CM_ SG_ 2400382534 CSC_Tcell_36_06 "温度36";
CM_ SG_ 2400382534 CSC_Tcell_37_06 "温度37";
CM_ SG_ 2400382534 CSC_Tcell_38_06 "温度38";
CM_ SG_ 2400382534 CSC_Tcell_39_06 "温度39";
CM_ SG_ 2400382534 CSC_Tcell_40_06 "温度40";
CM_ SG_ 2400382534 CSC_Tcell_41_06 "温度41";
CM_ SG_ 2400382534 CSC_Tcell_42_06 "温度42";
CM_ SG_ 2400382534 CSC_Tcell_43_06 "温度43";
CM_ SG_ 2400382534 CSC_Tcell_44_06 "温度44";
CM_ SG_ 2400382534 CSC_Tcell_45_06 "温度45";
CM_ SG_ 2400382534 CSC_Tcell_46_06 "温度46";
CM_ SG_ 2400382534 CSC_Tcell_47_06 "温度47";
CM_ SG_ 2400382534 CSC_Tcell_48_06 "温度48";
CM_ SG_ 2400382534 CSC_Tcell_49_06 "温度49";
CM_ SG_ 2400382534 CSC_Tcell_50_06 "温度50";
CM_ SG_ 2400382534 CSC_Tcell_51_06 "温度51";
CM_ SG_ 2400382534 CSC_Tcell_52_06 "温度52";
CM_ SG_ 2400382534 CSC_Tcell_53_06 "温度53";
CM_ SG_ 2400382534 CSC_Tcell_54_06 "温度54";
CM_ SG_ 2400382534 CSC_Tcell_55_06 "温度55";
CM_ SG_ 2400382534 CSC_Tcell_56_06 "温度56";
CM_ SG_ 2400382534 CSC_Tcell_57_06 "温度57";
CM_ SG_ 2400382534 CSC_Tcell_58_06 "温度58";
CM_ SG_ 2400382534 CSC_Tcell_59_06 "温度59";
CM_ SG_ 2400382534 CSC_Tcell_60_06 "温度60";
CM_ SG_ 2400382534 CSC_Tcell_61_06 "温度61";
CM_ SG_ 2400382534 CSC_Tcell_62_06 "温度62";
CM_ SG_ 2400382534 CSC_Tcell_63_06 "温度63";
CM_ SG_ 2400382534 CSC_Tcell_64_06 "温度64";
CM_ SG_ 2400382534 CSC_Tcell_65_06 "温度65";
CM_ SG_ 2400382534 CSC_Tcell_66_06 "温度66";
CM_ SG_ 2400382534 CSC_Tcell_67_06 "温度67";
CM_ SG_ 2400382534 CSC_Tcell_68_06 "温度68";
CM_ SG_ 2400382534 CSC_Tcell_69_06 "温度69";
CM_ SG_ 2400382534 CSC_Tcell_70_06 "温度70";
CM_ SG_ 2400382534 CSC_Tcell_71_06 "温度71";
CM_ SG_ 2400382534 CSC_Tcell_72_06 "温度72";
CM_ SG_ 2400382535 CSC_T_No_07 "CSC号";
CM_ SG_ 2400382535 CSC_Tcell_Frame_Index_07 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382535 CSC_Tcell_01_07 "温度01";
CM_ SG_ 2400382535 CSC_Tcell_02_07 "温度02";
CM_ SG_ 2400382535 CSC_Tcell_03_07 "温度03";
CM_ SG_ 2400382535 CSC_Tcell_04_07 "温度04";
CM_ SG_ 2400382535 CSC_Tcell_05_07 "温度05";
CM_ SG_ 2400382535 CSC_Tcell_06_07 "温度06";
CM_ SG_ 2400382535 CSC_Tcell_07_07 "温度07";
CM_ SG_ 2400382535 CSC_Tcell_08_07 "温度08";
CM_ SG_ 2400382535 CSC_Tcell_09_07 "温度09";
CM_ SG_ 2400382535 CSC_Tcell_10_07 "温度10";
CM_ SG_ 2400382535 CSC_Tcell_11_07 "温度11";
CM_ SG_ 2400382535 CSC_Tcell_12_07 "温度12";
CM_ SG_ 2400382535 CSC_Tcell_13_07 "温度13";
CM_ SG_ 2400382535 CSC_Tcell_14_07 "温度14";
CM_ SG_ 2400382535 CSC_Tcell_15_07 "温度15";
CM_ SG_ 2400382535 CSC_Tcell_16_07 "温度16";
CM_ SG_ 2400382535 CSC_Tcell_17_07 "温度17";
CM_ SG_ 2400382535 CSC_Tcell_18_07 "温度18";
CM_ SG_ 2400382535 CSC_Tcell_19_07 "温度19";
CM_ SG_ 2400382535 CSC_Tcell_20_07 "温度20";
CM_ SG_ 2400382535 CSC_Tcell_21_07 "温度21";
CM_ SG_ 2400382535 CSC_Tcell_22_07 "温度22";
CM_ SG_ 2400382535 CSC_Tcell_23_07 "温度23";
CM_ SG_ 2400382535 CSC_Tcell_24_07 "温度24";
CM_ SG_ 2400382535 CSC_Tcell_25_07 "温度25";
CM_ SG_ 2400382535 CSC_Tcell_26_07 "温度26";
CM_ SG_ 2400382535 CSC_Tcell_27_07 "温度27";
CM_ SG_ 2400382535 CSC_Tcell_28_07 "温度28";
CM_ SG_ 2400382535 CSC_Tcell_29_07 "温度29";
CM_ SG_ 2400382535 CSC_Tcell_30_07 "温度30";
CM_ SG_ 2400382535 CSC_Tcell_31_07 "温度31";
CM_ SG_ 2400382535 CSC_Tcell_32_07 "温度32";
CM_ SG_ 2400382535 CSC_Tcell_33_07 "温度33";
CM_ SG_ 2400382535 CSC_Tcell_34_07 "温度34";
CM_ SG_ 2400382535 CSC_Tcell_35_07 "温度35";
CM_ SG_ 2400382535 CSC_Tcell_36_07 "温度36";
CM_ SG_ 2400382535 CSC_Tcell_37_07 "温度37";
CM_ SG_ 2400382535 CSC_Tcell_38_07 "温度38";
CM_ SG_ 2400382535 CSC_Tcell_39_07 "温度39";
CM_ SG_ 2400382535 CSC_Tcell_40_07 "温度40";
CM_ SG_ 2400382535 CSC_Tcell_41_07 "温度41";
CM_ SG_ 2400382535 CSC_Tcell_42_07 "温度42";
CM_ SG_ 2400382535 CSC_Tcell_43_07 "温度43";
CM_ SG_ 2400382535 CSC_Tcell_44_07 "温度44";
CM_ SG_ 2400382535 CSC_Tcell_45_07 "温度45";
CM_ SG_ 2400382535 CSC_Tcell_46_07 "温度46";
CM_ SG_ 2400382535 CSC_Tcell_47_07 "温度47";
CM_ SG_ 2400382535 CSC_Tcell_48_07 "温度48";
CM_ SG_ 2400382535 CSC_Tcell_49_07 "温度49";
CM_ SG_ 2400382535 CSC_Tcell_50_07 "温度50";
CM_ SG_ 2400382535 CSC_Tcell_51_07 "温度51";
CM_ SG_ 2400382535 CSC_Tcell_52_07 "温度52";
CM_ SG_ 2400382535 CSC_Tcell_53_07 "温度53";
CM_ SG_ 2400382535 CSC_Tcell_54_07 "温度54";
CM_ SG_ 2400382535 CSC_Tcell_55_07 "温度55";
CM_ SG_ 2400382535 CSC_Tcell_56_07 "温度56";
CM_ SG_ 2400382535 CSC_Tcell_57_07 "温度57";
CM_ SG_ 2400382535 CSC_Tcell_58_07 "温度58";
CM_ SG_ 2400382535 CSC_Tcell_59_07 "温度59";
CM_ SG_ 2400382535 CSC_Tcell_60_07 "温度60";
CM_ SG_ 2400382535 CSC_Tcell_61_07 "温度61";
CM_ SG_ 2400382535 CSC_Tcell_62_07 "温度62";
CM_ SG_ 2400382535 CSC_Tcell_63_07 "温度63";
CM_ SG_ 2400382535 CSC_Tcell_64_07 "温度64";
CM_ SG_ 2400382535 CSC_Tcell_65_07 "温度65";
CM_ SG_ 2400382535 CSC_Tcell_66_07 "温度66";
CM_ SG_ 2400382535 CSC_Tcell_67_07 "温度67";
CM_ SG_ 2400382535 CSC_Tcell_68_07 "温度68";
CM_ SG_ 2400382535 CSC_Tcell_69_07 "温度69";
CM_ SG_ 2400382535 CSC_Tcell_70_07 "温度70";
CM_ SG_ 2400382535 CSC_Tcell_71_07 "温度71";
CM_ SG_ 2400382535 CSC_Tcell_72_07 "温度72";
CM_ SG_ 2400382536 CSC_T_No_08 "CSC号";
CM_ SG_ 2400382536 CSC_Tcell_Frame_Index_08 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382536 CSC_Tcell_01_08 "温度01";
CM_ SG_ 2400382536 CSC_Tcell_02_08 "温度02";
CM_ SG_ 2400382536 CSC_Tcell_03_08 "温度03";
CM_ SG_ 2400382536 CSC_Tcell_04_08 "温度04";
CM_ SG_ 2400382536 CSC_Tcell_05_08 "温度05";
CM_ SG_ 2400382536 CSC_Tcell_06_08 "温度06";
CM_ SG_ 2400382536 CSC_Tcell_07_08 "温度07";
CM_ SG_ 2400382536 CSC_Tcell_08_08 "温度08";
CM_ SG_ 2400382536 CSC_Tcell_09_08 "温度09";
CM_ SG_ 2400382536 CSC_Tcell_10_08 "温度10";
CM_ SG_ 2400382536 CSC_Tcell_11_08 "温度11";
CM_ SG_ 2400382536 CSC_Tcell_12_08 "温度12";
CM_ SG_ 2400382536 CSC_Tcell_13_08 "温度13";
CM_ SG_ 2400382536 CSC_Tcell_14_08 "温度14";
CM_ SG_ 2400382536 CSC_Tcell_15_08 "温度15";
CM_ SG_ 2400382536 CSC_Tcell_16_08 "温度16";
CM_ SG_ 2400382536 CSC_Tcell_17_08 "温度17";
CM_ SG_ 2400382536 CSC_Tcell_18_08 "温度18";
CM_ SG_ 2400382536 CSC_Tcell_19_08 "温度19";
CM_ SG_ 2400382536 CSC_Tcell_20_08 "温度20";
CM_ SG_ 2400382536 CSC_Tcell_21_08 "温度21";
CM_ SG_ 2400382536 CSC_Tcell_22_08 "温度22";
CM_ SG_ 2400382536 CSC_Tcell_23_08 "温度23";
CM_ SG_ 2400382536 CSC_Tcell_24_08 "温度24";
CM_ SG_ 2400382536 CSC_Tcell_25_08 "温度25";
CM_ SG_ 2400382536 CSC_Tcell_26_08 "温度26";
CM_ SG_ 2400382536 CSC_Tcell_27_08 "温度27";
CM_ SG_ 2400382536 CSC_Tcell_28_08 "温度28";
CM_ SG_ 2400382536 CSC_Tcell_29_08 "温度29";
CM_ SG_ 2400382536 CSC_Tcell_30_08 "温度30";
CM_ SG_ 2400382536 CSC_Tcell_31_08 "温度31";
CM_ SG_ 2400382536 CSC_Tcell_32_08 "温度32";
CM_ SG_ 2400382536 CSC_Tcell_33_08 "温度33";
CM_ SG_ 2400382536 CSC_Tcell_34_08 "温度34";
CM_ SG_ 2400382536 CSC_Tcell_35_08 "温度35";
CM_ SG_ 2400382536 CSC_Tcell_36_08 "温度36";
CM_ SG_ 2400382536 CSC_Tcell_37_08 "温度37";
CM_ SG_ 2400382536 CSC_Tcell_38_08 "温度38";
CM_ SG_ 2400382536 CSC_Tcell_39_08 "温度39";
CM_ SG_ 2400382536 CSC_Tcell_40_08 "温度40";
CM_ SG_ 2400382536 CSC_Tcell_41_08 "温度41";
CM_ SG_ 2400382536 CSC_Tcell_42_08 "温度42";
CM_ SG_ 2400382536 CSC_Tcell_43_08 "温度43";
CM_ SG_ 2400382536 CSC_Tcell_44_08 "温度44";
CM_ SG_ 2400382536 CSC_Tcell_45_08 "温度45";
CM_ SG_ 2400382536 CSC_Tcell_46_08 "温度46";
CM_ SG_ 2400382536 CSC_Tcell_47_08 "温度47";
CM_ SG_ 2400382536 CSC_Tcell_48_08 "温度48";
CM_ SG_ 2400382536 CSC_Tcell_49_08 "温度49";
CM_ SG_ 2400382536 CSC_Tcell_50_08 "温度50";
CM_ SG_ 2400382536 CSC_Tcell_51_08 "温度51";
CM_ SG_ 2400382536 CSC_Tcell_52_08 "温度52";
CM_ SG_ 2400382536 CSC_Tcell_53_08 "温度53";
CM_ SG_ 2400382536 CSC_Tcell_54_08 "温度54";
CM_ SG_ 2400382536 CSC_Tcell_55_08 "温度55";
CM_ SG_ 2400382536 CSC_Tcell_56_08 "温度56";
CM_ SG_ 2400382536 CSC_Tcell_57_08 "温度57";
CM_ SG_ 2400382536 CSC_Tcell_58_08 "温度58";
CM_ SG_ 2400382536 CSC_Tcell_59_08 "温度59";
CM_ SG_ 2400382536 CSC_Tcell_60_08 "温度60";
CM_ SG_ 2400382536 CSC_Tcell_61_08 "温度61";
CM_ SG_ 2400382536 CSC_Tcell_62_08 "温度62";
CM_ SG_ 2400382536 CSC_Tcell_63_08 "温度63";
CM_ SG_ 2400382536 CSC_Tcell_64_08 "温度64";
CM_ SG_ 2400382536 CSC_Tcell_65_08 "温度65";
CM_ SG_ 2400382536 CSC_Tcell_66_08 "温度66";
CM_ SG_ 2400382536 CSC_Tcell_67_08 "温度67";
CM_ SG_ 2400382536 CSC_Tcell_68_08 "温度68";
CM_ SG_ 2400382536 CSC_Tcell_69_08 "温度69";
CM_ SG_ 2400382536 CSC_Tcell_70_08 "温度70";
CM_ SG_ 2400382536 CSC_Tcell_71_08 "温度71";
CM_ SG_ 2400382536 CSC_Tcell_72_08 "温度72";
CM_ SG_ 2400382537 CSC_T_No_09 "CSC号";
CM_ SG_ 2400382537 CSC_Tcell_Frame_Index_09 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382537 CSC_Tcell_01_09 "温度01";
CM_ SG_ 2400382537 CSC_Tcell_02_09 "温度02";
CM_ SG_ 2400382537 CSC_Tcell_03_09 "温度03";
CM_ SG_ 2400382537 CSC_Tcell_04_09 "温度04";
CM_ SG_ 2400382537 CSC_Tcell_05_09 "温度05";
CM_ SG_ 2400382537 CSC_Tcell_06_09 "温度06";
CM_ SG_ 2400382537 CSC_Tcell_07_09 "温度07";
CM_ SG_ 2400382537 CSC_Tcell_08_09 "温度08";
CM_ SG_ 2400382537 CSC_Tcell_09_09 "温度09";
CM_ SG_ 2400382537 CSC_Tcell_10_09 "温度10";
CM_ SG_ 2400382537 CSC_Tcell_11_09 "温度11";
CM_ SG_ 2400382537 CSC_Tcell_12_09 "温度12";
CM_ SG_ 2400382537 CSC_Tcell_13_09 "温度13";
CM_ SG_ 2400382537 CSC_Tcell_14_09 "温度14";
CM_ SG_ 2400382537 CSC_Tcell_15_09 "温度15";
CM_ SG_ 2400382537 CSC_Tcell_16_09 "温度16";
CM_ SG_ 2400382537 CSC_Tcell_17_09 "温度17";
CM_ SG_ 2400382537 CSC_Tcell_18_09 "温度18";
CM_ SG_ 2400382537 CSC_Tcell_19_09 "温度19";
CM_ SG_ 2400382537 CSC_Tcell_20_09 "温度20";
CM_ SG_ 2400382537 CSC_Tcell_21_09 "温度21";
CM_ SG_ 2400382537 CSC_Tcell_22_09 "温度22";
CM_ SG_ 2400382537 CSC_Tcell_23_09 "温度23";
CM_ SG_ 2400382537 CSC_Tcell_24_09 "温度24";
CM_ SG_ 2400382537 CSC_Tcell_25_09 "温度25";
CM_ SG_ 2400382537 CSC_Tcell_26_09 "温度26";
CM_ SG_ 2400382537 CSC_Tcell_27_09 "温度27";
CM_ SG_ 2400382537 CSC_Tcell_28_09 "温度28";
CM_ SG_ 2400382537 CSC_Tcell_29_09 "温度29";
CM_ SG_ 2400382537 CSC_Tcell_30_09 "温度30";
CM_ SG_ 2400382537 CSC_Tcell_31_09 "温度31";
CM_ SG_ 2400382537 CSC_Tcell_32_09 "温度32";
CM_ SG_ 2400382537 CSC_Tcell_33_09 "温度33";
CM_ SG_ 2400382537 CSC_Tcell_34_09 "温度34";
CM_ SG_ 2400382537 CSC_Tcell_35_09 "温度35";
CM_ SG_ 2400382537 CSC_Tcell_36_09 "温度36";
CM_ SG_ 2400382537 CSC_Tcell_37_09 "温度37";
CM_ SG_ 2400382537 CSC_Tcell_38_09 "温度38";
CM_ SG_ 2400382537 CSC_Tcell_39_09 "温度39";
CM_ SG_ 2400382537 CSC_Tcell_40_09 "温度40";
CM_ SG_ 2400382537 CSC_Tcell_41_09 "温度41";
CM_ SG_ 2400382537 CSC_Tcell_42_09 "温度42";
CM_ SG_ 2400382537 CSC_Tcell_43_09 "温度43";
CM_ SG_ 2400382537 CSC_Tcell_44_09 "温度44";
CM_ SG_ 2400382537 CSC_Tcell_45_09 "温度45";
CM_ SG_ 2400382537 CSC_Tcell_46_09 "温度46";
CM_ SG_ 2400382537 CSC_Tcell_47_09 "温度47";
CM_ SG_ 2400382537 CSC_Tcell_48_09 "温度48";
CM_ SG_ 2400382537 CSC_Tcell_49_09 "温度49";
CM_ SG_ 2400382537 CSC_Tcell_50_09 "温度50";
CM_ SG_ 2400382537 CSC_Tcell_51_09 "温度51";
CM_ SG_ 2400382537 CSC_Tcell_52_09 "温度52";
CM_ SG_ 2400382537 CSC_Tcell_53_09 "温度53";
CM_ SG_ 2400382537 CSC_Tcell_54_09 "温度54";
CM_ SG_ 2400382537 CSC_Tcell_55_09 "温度55";
CM_ SG_ 2400382537 CSC_Tcell_56_09 "温度56";
CM_ SG_ 2400382537 CSC_Tcell_57_09 "温度57";
CM_ SG_ 2400382537 CSC_Tcell_58_09 "温度58";
CM_ SG_ 2400382537 CSC_Tcell_59_09 "温度59";
CM_ SG_ 2400382537 CSC_Tcell_60_09 "温度60";
CM_ SG_ 2400382537 CSC_Tcell_61_09 "温度61";
CM_ SG_ 2400382537 CSC_Tcell_62_09 "温度62";
CM_ SG_ 2400382537 CSC_Tcell_63_09 "温度63";
CM_ SG_ 2400382537 CSC_Tcell_64_09 "温度64";
CM_ SG_ 2400382537 CSC_Tcell_65_09 "温度65";
CM_ SG_ 2400382537 CSC_Tcell_66_09 "温度66";
CM_ SG_ 2400382537 CSC_Tcell_67_09 "温度67";
CM_ SG_ 2400382537 CSC_Tcell_68_09 "温度68";
CM_ SG_ 2400382537 CSC_Tcell_69_09 "温度69";
CM_ SG_ 2400382537 CSC_Tcell_70_09 "温度70";
CM_ SG_ 2400382537 CSC_Tcell_71_09 "温度71";
CM_ SG_ 2400382537 CSC_Tcell_72_09 "温度72";
CM_ SG_ 2400382538 CSC_T_No_10 "CSC号";
CM_ SG_ 2400382538 CSC_Tcell_Frame_Index_10 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382538 CSC_Tcell_01_10 "温度01";
CM_ SG_ 2400382538 CSC_Tcell_02_10 "温度02";
CM_ SG_ 2400382538 CSC_Tcell_03_10 "温度03";
CM_ SG_ 2400382538 CSC_Tcell_04_10 "温度04";
CM_ SG_ 2400382538 CSC_Tcell_05_10 "温度05";
CM_ SG_ 2400382538 CSC_Tcell_06_10 "温度06";
CM_ SG_ 2400382538 CSC_Tcell_07_10 "温度07";
CM_ SG_ 2400382538 CSC_Tcell_08_10 "温度08";
CM_ SG_ 2400382538 CSC_Tcell_09_10 "温度09";
CM_ SG_ 2400382538 CSC_Tcell_10_10 "温度10";
CM_ SG_ 2400382538 CSC_Tcell_11_10 "温度11";
CM_ SG_ 2400382538 CSC_Tcell_12_10 "温度12";
CM_ SG_ 2400382538 CSC_Tcell_13_10 "温度13";
CM_ SG_ 2400382538 CSC_Tcell_14_10 "温度14";
CM_ SG_ 2400382538 CSC_Tcell_15_10 "温度15";
CM_ SG_ 2400382538 CSC_Tcell_16_10 "温度16";
CM_ SG_ 2400382538 CSC_Tcell_17_10 "温度17";
CM_ SG_ 2400382538 CSC_Tcell_18_10 "温度18";
CM_ SG_ 2400382538 CSC_Tcell_19_10 "温度19";
CM_ SG_ 2400382538 CSC_Tcell_20_10 "温度20";
CM_ SG_ 2400382538 CSC_Tcell_21_10 "温度21";
CM_ SG_ 2400382538 CSC_Tcell_22_10 "温度22";
CM_ SG_ 2400382538 CSC_Tcell_23_10 "温度23";
CM_ SG_ 2400382538 CSC_Tcell_24_10 "温度24";
CM_ SG_ 2400382538 CSC_Tcell_25_10 "温度25";
CM_ SG_ 2400382538 CSC_Tcell_26_10 "温度26";
CM_ SG_ 2400382538 CSC_Tcell_27_10 "温度27";
CM_ SG_ 2400382538 CSC_Tcell_28_10 "温度28";
CM_ SG_ 2400382538 CSC_Tcell_29_10 "温度29";
CM_ SG_ 2400382538 CSC_Tcell_30_10 "温度30";
CM_ SG_ 2400382538 CSC_Tcell_31_10 "温度31";
CM_ SG_ 2400382538 CSC_Tcell_32_10 "温度32";
CM_ SG_ 2400382538 CSC_Tcell_33_10 "温度33";
CM_ SG_ 2400382538 CSC_Tcell_34_10 "温度34";
CM_ SG_ 2400382538 CSC_Tcell_35_10 "温度35";
CM_ SG_ 2400382538 CSC_Tcell_36_10 "温度36";
CM_ SG_ 2400382538 CSC_Tcell_37_10 "温度37";
CM_ SG_ 2400382538 CSC_Tcell_38_10 "温度38";
CM_ SG_ 2400382538 CSC_Tcell_39_10 "温度39";
CM_ SG_ 2400382538 CSC_Tcell_40_10 "温度40";
CM_ SG_ 2400382538 CSC_Tcell_41_10 "温度41";
CM_ SG_ 2400382538 CSC_Tcell_42_10 "温度42";
CM_ SG_ 2400382538 CSC_Tcell_43_10 "温度43";
CM_ SG_ 2400382538 CSC_Tcell_44_10 "温度44";
CM_ SG_ 2400382538 CSC_Tcell_45_10 "温度45";
CM_ SG_ 2400382538 CSC_Tcell_46_10 "温度46";
CM_ SG_ 2400382538 CSC_Tcell_47_10 "温度47";
CM_ SG_ 2400382538 CSC_Tcell_48_10 "温度48";
CM_ SG_ 2400382538 CSC_Tcell_49_10 "温度49";
CM_ SG_ 2400382538 CSC_Tcell_50_10 "温度50";
CM_ SG_ 2400382538 CSC_Tcell_51_10 "温度51";
CM_ SG_ 2400382538 CSC_Tcell_52_10 "温度52";
CM_ SG_ 2400382538 CSC_Tcell_53_10 "温度53";
CM_ SG_ 2400382538 CSC_Tcell_54_10 "温度54";
CM_ SG_ 2400382538 CSC_Tcell_55_10 "温度55";
CM_ SG_ 2400382538 CSC_Tcell_56_10 "温度56";
CM_ SG_ 2400382538 CSC_Tcell_57_10 "温度57";
CM_ SG_ 2400382538 CSC_Tcell_58_10 "温度58";
CM_ SG_ 2400382538 CSC_Tcell_59_10 "温度59";
CM_ SG_ 2400382538 CSC_Tcell_60_10 "温度60";
CM_ SG_ 2400382538 CSC_Tcell_61_10 "温度61";
CM_ SG_ 2400382538 CSC_Tcell_62_10 "温度62";
CM_ SG_ 2400382538 CSC_Tcell_63_10 "温度63";
CM_ SG_ 2400382538 CSC_Tcell_64_10 "温度64";
CM_ SG_ 2400382538 CSC_Tcell_65_10 "温度65";
CM_ SG_ 2400382538 CSC_Tcell_66_10 "温度66";
CM_ SG_ 2400382538 CSC_Tcell_67_10 "温度67";
CM_ SG_ 2400382538 CSC_Tcell_68_10 "温度68";
CM_ SG_ 2400382538 CSC_Tcell_69_10 "温度69";
CM_ SG_ 2400382538 CSC_Tcell_70_10 "温度70";
CM_ SG_ 2400382538 CSC_Tcell_71_10 "温度71";
CM_ SG_ 2400382538 CSC_Tcell_72_10 "温度72";
CM_ SG_ 2400382539 CSC_T_No_11 "CSC号";
CM_ SG_ 2400382539 CSC_Tcell_Frame_Index_11 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382539 CSC_Tcell_01_11 "温度01";
CM_ SG_ 2400382539 CSC_Tcell_02_11 "温度02";
CM_ SG_ 2400382539 CSC_Tcell_03_11 "温度03";
CM_ SG_ 2400382539 CSC_Tcell_04_11 "温度04";
CM_ SG_ 2400382539 CSC_Tcell_05_11 "温度05";
CM_ SG_ 2400382539 CSC_Tcell_06_11 "温度06";
CM_ SG_ 2400382539 CSC_Tcell_07_11 "温度07";
CM_ SG_ 2400382539 CSC_Tcell_08_11 "温度08";
CM_ SG_ 2400382539 CSC_Tcell_09_11 "温度09";
CM_ SG_ 2400382539 CSC_Tcell_10_11 "温度10";
CM_ SG_ 2400382539 CSC_Tcell_11_11 "温度11";
CM_ SG_ 2400382539 CSC_Tcell_12_11 "温度12";
CM_ SG_ 2400382539 CSC_Tcell_13_11 "温度13";
CM_ SG_ 2400382539 CSC_Tcell_14_11 "温度14";
CM_ SG_ 2400382539 CSC_Tcell_15_11 "温度15";
CM_ SG_ 2400382539 CSC_Tcell_16_11 "温度16";
CM_ SG_ 2400382539 CSC_Tcell_17_11 "温度17";
CM_ SG_ 2400382539 CSC_Tcell_18_11 "温度18";
CM_ SG_ 2400382539 CSC_Tcell_19_11 "温度19";
CM_ SG_ 2400382539 CSC_Tcell_20_11 "温度20";
CM_ SG_ 2400382539 CSC_Tcell_21_11 "温度21";
CM_ SG_ 2400382539 CSC_Tcell_22_11 "温度22";
CM_ SG_ 2400382539 CSC_Tcell_23_11 "温度23";
CM_ SG_ 2400382539 CSC_Tcell_24_11 "温度24";
CM_ SG_ 2400382539 CSC_Tcell_25_11 "温度25";
CM_ SG_ 2400382539 CSC_Tcell_26_11 "温度26";
CM_ SG_ 2400382539 CSC_Tcell_27_11 "温度27";
CM_ SG_ 2400382539 CSC_Tcell_28_11 "温度28";
CM_ SG_ 2400382539 CSC_Tcell_29_11 "温度29";
CM_ SG_ 2400382539 CSC_Tcell_30_11 "温度30";
CM_ SG_ 2400382539 CSC_Tcell_31_11 "温度31";
CM_ SG_ 2400382539 CSC_Tcell_32_11 "温度32";
CM_ SG_ 2400382539 CSC_Tcell_33_11 "温度33";
CM_ SG_ 2400382539 CSC_Tcell_34_11 "温度34";
CM_ SG_ 2400382539 CSC_Tcell_35_11 "温度35";
CM_ SG_ 2400382539 CSC_Tcell_36_11 "温度36";
CM_ SG_ 2400382539 CSC_Tcell_37_11 "温度37";
CM_ SG_ 2400382539 CSC_Tcell_38_11 "温度38";
CM_ SG_ 2400382539 CSC_Tcell_39_11 "温度39";
CM_ SG_ 2400382539 CSC_Tcell_40_11 "温度40";
CM_ SG_ 2400382539 CSC_Tcell_41_11 "温度41";
CM_ SG_ 2400382539 CSC_Tcell_42_11 "温度42";
CM_ SG_ 2400382539 CSC_Tcell_43_11 "温度43";
CM_ SG_ 2400382539 CSC_Tcell_44_11 "温度44";
CM_ SG_ 2400382539 CSC_Tcell_45_11 "温度45";
CM_ SG_ 2400382539 CSC_Tcell_46_11 "温度46";
CM_ SG_ 2400382539 CSC_Tcell_47_11 "温度47";
CM_ SG_ 2400382539 CSC_Tcell_48_11 "温度48";
CM_ SG_ 2400382539 CSC_Tcell_49_11 "温度49";
CM_ SG_ 2400382539 CSC_Tcell_50_11 "温度50";
CM_ SG_ 2400382539 CSC_Tcell_51_11 "温度51";
CM_ SG_ 2400382539 CSC_Tcell_52_11 "温度52";
CM_ SG_ 2400382539 CSC_Tcell_53_11 "温度53";
CM_ SG_ 2400382539 CSC_Tcell_54_11 "温度54";
CM_ SG_ 2400382539 CSC_Tcell_55_11 "温度55";
CM_ SG_ 2400382539 CSC_Tcell_56_11 "温度56";
CM_ SG_ 2400382539 CSC_Tcell_57_11 "温度57";
CM_ SG_ 2400382539 CSC_Tcell_58_11 "温度58";
CM_ SG_ 2400382539 CSC_Tcell_59_11 "温度59";
CM_ SG_ 2400382539 CSC_Tcell_60_11 "温度60";
CM_ SG_ 2400382539 CSC_Tcell_61_11 "温度61";
CM_ SG_ 2400382539 CSC_Tcell_62_11 "温度62";
CM_ SG_ 2400382539 CSC_Tcell_63_11 "温度63";
CM_ SG_ 2400382539 CSC_Tcell_64_11 "温度64";
CM_ SG_ 2400382539 CSC_Tcell_65_11 "温度65";
CM_ SG_ 2400382539 CSC_Tcell_66_11 "温度66";
CM_ SG_ 2400382539 CSC_Tcell_67_11 "温度67";
CM_ SG_ 2400382539 CSC_Tcell_68_11 "温度68";
CM_ SG_ 2400382539 CSC_Tcell_69_11 "温度69";
CM_ SG_ 2400382539 CSC_Tcell_70_11 "温度70";
CM_ SG_ 2400382539 CSC_Tcell_71_11 "温度71";
CM_ SG_ 2400382539 CSC_Tcell_72_11 "温度72";
CM_ SG_ 2400382540 CSC_T_No_12 "CSC号";
CM_ SG_ 2400382540 CSC_Tcell_Frame_Index_12 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382540 CSC_Tcell_01_12 "温度01";
CM_ SG_ 2400382540 CSC_Tcell_02_12 "温度02";
CM_ SG_ 2400382540 CSC_Tcell_03_12 "温度03";
CM_ SG_ 2400382540 CSC_Tcell_04_12 "温度04";
CM_ SG_ 2400382540 CSC_Tcell_05_12 "温度05";
CM_ SG_ 2400382540 CSC_Tcell_06_12 "温度06";
CM_ SG_ 2400382540 CSC_Tcell_07_12 "温度07";
CM_ SG_ 2400382540 CSC_Tcell_08_12 "温度08";
CM_ SG_ 2400382540 CSC_Tcell_09_12 "温度09";
CM_ SG_ 2400382540 CSC_Tcell_10_12 "温度10";
CM_ SG_ 2400382540 CSC_Tcell_11_12 "温度11";
CM_ SG_ 2400382540 CSC_Tcell_12_12 "温度12";
CM_ SG_ 2400382540 CSC_Tcell_13_12 "温度13";
CM_ SG_ 2400382540 CSC_Tcell_14_12 "温度14";
CM_ SG_ 2400382540 CSC_Tcell_15_12 "温度15";
CM_ SG_ 2400382540 CSC_Tcell_16_12 "温度16";
CM_ SG_ 2400382540 CSC_Tcell_17_12 "温度17";
CM_ SG_ 2400382540 CSC_Tcell_18_12 "温度18";
CM_ SG_ 2400382540 CSC_Tcell_19_12 "温度19";
CM_ SG_ 2400382540 CSC_Tcell_20_12 "温度20";
CM_ SG_ 2400382540 CSC_Tcell_21_12 "温度21";
CM_ SG_ 2400382540 CSC_Tcell_22_12 "温度22";
CM_ SG_ 2400382540 CSC_Tcell_23_12 "温度23";
CM_ SG_ 2400382540 CSC_Tcell_24_12 "温度24";
CM_ SG_ 2400382540 CSC_Tcell_25_12 "温度25";
CM_ SG_ 2400382540 CSC_Tcell_26_12 "温度26";
CM_ SG_ 2400382540 CSC_Tcell_27_12 "温度27";
CM_ SG_ 2400382540 CSC_Tcell_28_12 "温度28";
CM_ SG_ 2400382540 CSC_Tcell_29_12 "温度29";
CM_ SG_ 2400382540 CSC_Tcell_30_12 "温度30";
CM_ SG_ 2400382540 CSC_Tcell_31_12 "温度31";
CM_ SG_ 2400382540 CSC_Tcell_32_12 "温度32";
CM_ SG_ 2400382540 CSC_Tcell_33_12 "温度33";
CM_ SG_ 2400382540 CSC_Tcell_34_12 "温度34";
CM_ SG_ 2400382540 CSC_Tcell_35_12 "温度35";
CM_ SG_ 2400382540 CSC_Tcell_36_12 "温度36";
CM_ SG_ 2400382540 CSC_Tcell_37_12 "温度37";
CM_ SG_ 2400382540 CSC_Tcell_38_12 "温度38";
CM_ SG_ 2400382540 CSC_Tcell_39_12 "温度39";
CM_ SG_ 2400382540 CSC_Tcell_40_12 "温度40";
CM_ SG_ 2400382540 CSC_Tcell_41_12 "温度41";
CM_ SG_ 2400382540 CSC_Tcell_42_12 "温度42";
CM_ SG_ 2400382540 CSC_Tcell_43_12 "温度43";
CM_ SG_ 2400382540 CSC_Tcell_44_12 "温度44";
CM_ SG_ 2400382540 CSC_Tcell_45_12 "温度45";
CM_ SG_ 2400382540 CSC_Tcell_46_12 "温度46";
CM_ SG_ 2400382540 CSC_Tcell_47_12 "温度47";
CM_ SG_ 2400382540 CSC_Tcell_48_12 "温度48";
CM_ SG_ 2400382540 CSC_Tcell_49_12 "温度49";
CM_ SG_ 2400382540 CSC_Tcell_50_12 "温度50";
CM_ SG_ 2400382540 CSC_Tcell_51_12 "温度51";
CM_ SG_ 2400382540 CSC_Tcell_52_12 "温度52";
CM_ SG_ 2400382540 CSC_Tcell_53_12 "温度53";
CM_ SG_ 2400382540 CSC_Tcell_54_12 "温度54";
CM_ SG_ 2400382540 CSC_Tcell_55_12 "温度55";
CM_ SG_ 2400382540 CSC_Tcell_56_12 "温度56";
CM_ SG_ 2400382540 CSC_Tcell_57_12 "温度57";
CM_ SG_ 2400382540 CSC_Tcell_58_12 "温度58";
CM_ SG_ 2400382540 CSC_Tcell_59_12 "温度59";
CM_ SG_ 2400382540 CSC_Tcell_60_12 "温度60";
CM_ SG_ 2400382540 CSC_Tcell_61_12 "温度61";
CM_ SG_ 2400382540 CSC_Tcell_62_12 "温度62";
CM_ SG_ 2400382540 CSC_Tcell_63_12 "温度63";
CM_ SG_ 2400382540 CSC_Tcell_64_12 "温度64";
CM_ SG_ 2400382540 CSC_Tcell_65_12 "温度65";
CM_ SG_ 2400382540 CSC_Tcell_66_12 "温度66";
CM_ SG_ 2400382540 CSC_Tcell_67_12 "温度67";
CM_ SG_ 2400382540 CSC_Tcell_68_12 "温度68";
CM_ SG_ 2400382540 CSC_Tcell_69_12 "温度69";
CM_ SG_ 2400382540 CSC_Tcell_70_12 "温度70";
CM_ SG_ 2400382540 CSC_Tcell_71_12 "温度71";
CM_ SG_ 2400382540 CSC_Tcell_72_12 "温度72";
CM_ SG_ 2400382541 CSC_T_No_13 "CSC号";
CM_ SG_ 2400382541 CSC_Tcell_Frame_Index_13 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382541 CSC_Tcell_01_13 "温度01";
CM_ SG_ 2400382541 CSC_Tcell_02_13 "温度02";
CM_ SG_ 2400382541 CSC_Tcell_03_13 "温度03";
CM_ SG_ 2400382541 CSC_Tcell_04_13 "温度04";
CM_ SG_ 2400382541 CSC_Tcell_05_13 "温度05";
CM_ SG_ 2400382541 CSC_Tcell_06_13 "温度06";
CM_ SG_ 2400382541 CSC_Tcell_07_13 "温度07";
CM_ SG_ 2400382541 CSC_Tcell_08_13 "温度08";
CM_ SG_ 2400382541 CSC_Tcell_09_13 "温度09";
CM_ SG_ 2400382541 CSC_Tcell_10_13 "温度10";
CM_ SG_ 2400382541 CSC_Tcell_11_13 "温度11";
CM_ SG_ 2400382541 CSC_Tcell_12_13 "温度12";
CM_ SG_ 2400382541 CSC_Tcell_13_13 "温度13";
CM_ SG_ 2400382541 CSC_Tcell_14_13 "温度14";
CM_ SG_ 2400382541 CSC_Tcell_15_13 "温度15";
CM_ SG_ 2400382541 CSC_Tcell_16_13 "温度16";
CM_ SG_ 2400382541 CSC_Tcell_17_13 "温度17";
CM_ SG_ 2400382541 CSC_Tcell_18_13 "温度18";
CM_ SG_ 2400382541 CSC_Tcell_19_13 "温度19";
CM_ SG_ 2400382541 CSC_Tcell_20_13 "温度20";
CM_ SG_ 2400382541 CSC_Tcell_21_13 "温度21";
CM_ SG_ 2400382541 CSC_Tcell_22_13 "温度22";
CM_ SG_ 2400382541 CSC_Tcell_23_13 "温度23";
CM_ SG_ 2400382541 CSC_Tcell_24_13 "温度24";
CM_ SG_ 2400382541 CSC_Tcell_25_13 "温度25";
CM_ SG_ 2400382541 CSC_Tcell_26_13 "温度26";
CM_ SG_ 2400382541 CSC_Tcell_27_13 "温度27";
CM_ SG_ 2400382541 CSC_Tcell_28_13 "温度28";
CM_ SG_ 2400382541 CSC_Tcell_29_13 "温度29";
CM_ SG_ 2400382541 CSC_Tcell_30_13 "温度30";
CM_ SG_ 2400382541 CSC_Tcell_31_13 "温度31";
CM_ SG_ 2400382541 CSC_Tcell_32_13 "温度32";
CM_ SG_ 2400382541 CSC_Tcell_33_13 "温度33";
CM_ SG_ 2400382541 CSC_Tcell_34_13 "温度34";
CM_ SG_ 2400382541 CSC_Tcell_35_13 "温度35";
CM_ SG_ 2400382541 CSC_Tcell_36_13 "温度36";
CM_ SG_ 2400382541 CSC_Tcell_37_13 "温度37";
CM_ SG_ 2400382541 CSC_Tcell_38_13 "温度38";
CM_ SG_ 2400382541 CSC_Tcell_39_13 "温度39";
CM_ SG_ 2400382541 CSC_Tcell_40_13 "温度40";
CM_ SG_ 2400382541 CSC_Tcell_41_13 "温度41";
CM_ SG_ 2400382541 CSC_Tcell_42_13 "温度42";
CM_ SG_ 2400382541 CSC_Tcell_43_13 "温度43";
CM_ SG_ 2400382541 CSC_Tcell_44_13 "温度44";
CM_ SG_ 2400382541 CSC_Tcell_45_13 "温度45";
CM_ SG_ 2400382541 CSC_Tcell_46_13 "温度46";
CM_ SG_ 2400382541 CSC_Tcell_47_13 "温度47";
CM_ SG_ 2400382541 CSC_Tcell_48_13 "温度48";
CM_ SG_ 2400382541 CSC_Tcell_49_13 "温度49";
CM_ SG_ 2400382541 CSC_Tcell_50_13 "温度50";
CM_ SG_ 2400382541 CSC_Tcell_51_13 "温度51";
CM_ SG_ 2400382541 CSC_Tcell_52_13 "温度52";
CM_ SG_ 2400382541 CSC_Tcell_53_13 "温度53";
CM_ SG_ 2400382541 CSC_Tcell_54_13 "温度54";
CM_ SG_ 2400382541 CSC_Tcell_55_13 "温度55";
CM_ SG_ 2400382541 CSC_Tcell_56_13 "温度56";
CM_ SG_ 2400382541 CSC_Tcell_57_13 "温度57";
CM_ SG_ 2400382541 CSC_Tcell_58_13 "温度58";
CM_ SG_ 2400382541 CSC_Tcell_59_13 "温度59";
CM_ SG_ 2400382541 CSC_Tcell_60_13 "温度60";
CM_ SG_ 2400382541 CSC_Tcell_61_13 "温度61";
CM_ SG_ 2400382541 CSC_Tcell_62_13 "温度62";
CM_ SG_ 2400382541 CSC_Tcell_63_13 "温度63";
CM_ SG_ 2400382541 CSC_Tcell_64_13 "温度64";
CM_ SG_ 2400382541 CSC_Tcell_65_13 "温度65";
CM_ SG_ 2400382541 CSC_Tcell_66_13 "温度66";
CM_ SG_ 2400382541 CSC_Tcell_67_13 "温度67";
CM_ SG_ 2400382541 CSC_Tcell_68_13 "温度68";
CM_ SG_ 2400382541 CSC_Tcell_69_13 "温度69";
CM_ SG_ 2400382541 CSC_Tcell_70_13 "温度70";
CM_ SG_ 2400382541 CSC_Tcell_71_13 "温度71";
CM_ SG_ 2400382541 CSC_Tcell_72_13 "温度72";
CM_ SG_ 2400382542 CSC_T_No_14 "CSC号";
CM_ SG_ 2400382542 CSC_Tcell_Frame_Index_14 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382542 CSC_Tcell_01_14 "温度01";
CM_ SG_ 2400382542 CSC_Tcell_02_14 "温度02";
CM_ SG_ 2400382542 CSC_Tcell_03_14 "温度03";
CM_ SG_ 2400382542 CSC_Tcell_04_14 "温度04";
CM_ SG_ 2400382542 CSC_Tcell_05_14 "温度05";
CM_ SG_ 2400382542 CSC_Tcell_06_14 "温度06";
CM_ SG_ 2400382542 CSC_Tcell_07_14 "温度07";
CM_ SG_ 2400382542 CSC_Tcell_08_14 "温度08";
CM_ SG_ 2400382542 CSC_Tcell_09_14 "温度09";
CM_ SG_ 2400382542 CSC_Tcell_10_14 "温度10";
CM_ SG_ 2400382542 CSC_Tcell_11_14 "温度11";
CM_ SG_ 2400382542 CSC_Tcell_12_14 "温度12";
CM_ SG_ 2400382542 CSC_Tcell_13_14 "温度13";
CM_ SG_ 2400382542 CSC_Tcell_14_14 "温度14";
CM_ SG_ 2400382542 CSC_Tcell_15_14 "温度15";
CM_ SG_ 2400382542 CSC_Tcell_16_14 "温度16";
CM_ SG_ 2400382542 CSC_Tcell_17_14 "温度17";
CM_ SG_ 2400382542 CSC_Tcell_18_14 "温度18";
CM_ SG_ 2400382542 CSC_Tcell_19_14 "温度19";
CM_ SG_ 2400382542 CSC_Tcell_20_14 "温度20";
CM_ SG_ 2400382542 CSC_Tcell_21_14 "温度21";
CM_ SG_ 2400382542 CSC_Tcell_22_14 "温度22";
CM_ SG_ 2400382542 CSC_Tcell_23_14 "温度23";
CM_ SG_ 2400382542 CSC_Tcell_24_14 "温度24";
CM_ SG_ 2400382542 CSC_Tcell_25_14 "温度25";
CM_ SG_ 2400382542 CSC_Tcell_26_14 "温度26";
CM_ SG_ 2400382542 CSC_Tcell_27_14 "温度27";
CM_ SG_ 2400382542 CSC_Tcell_28_14 "温度28";
CM_ SG_ 2400382542 CSC_Tcell_29_14 "温度29";
CM_ SG_ 2400382542 CSC_Tcell_30_14 "温度30";
CM_ SG_ 2400382542 CSC_Tcell_31_14 "温度31";
CM_ SG_ 2400382542 CSC_Tcell_32_14 "温度32";
CM_ SG_ 2400382542 CSC_Tcell_33_14 "温度33";
CM_ SG_ 2400382542 CSC_Tcell_34_14 "温度34";
CM_ SG_ 2400382542 CSC_Tcell_35_14 "温度35";
CM_ SG_ 2400382542 CSC_Tcell_36_14 "温度36";
CM_ SG_ 2400382542 CSC_Tcell_37_14 "温度37";
CM_ SG_ 2400382542 CSC_Tcell_38_14 "温度38";
CM_ SG_ 2400382542 CSC_Tcell_39_14 "温度39";
CM_ SG_ 2400382542 CSC_Tcell_40_14 "温度40";
CM_ SG_ 2400382542 CSC_Tcell_41_14 "温度41";
CM_ SG_ 2400382542 CSC_Tcell_42_14 "温度42";
CM_ SG_ 2400382542 CSC_Tcell_43_14 "温度43";
CM_ SG_ 2400382542 CSC_Tcell_44_14 "温度44";
CM_ SG_ 2400382542 CSC_Tcell_45_14 "温度45";
CM_ SG_ 2400382542 CSC_Tcell_46_14 "温度46";
CM_ SG_ 2400382542 CSC_Tcell_47_14 "温度47";
CM_ SG_ 2400382542 CSC_Tcell_48_14 "温度48";
CM_ SG_ 2400382542 CSC_Tcell_49_14 "温度49";
CM_ SG_ 2400382542 CSC_Tcell_50_14 "温度50";
CM_ SG_ 2400382542 CSC_Tcell_51_14 "温度51";
CM_ SG_ 2400382542 CSC_Tcell_52_14 "温度52";
CM_ SG_ 2400382542 CSC_Tcell_53_14 "温度53";
CM_ SG_ 2400382542 CSC_Tcell_54_14 "温度54";
CM_ SG_ 2400382542 CSC_Tcell_55_14 "温度55";
CM_ SG_ 2400382542 CSC_Tcell_56_14 "温度56";
CM_ SG_ 2400382542 CSC_Tcell_57_14 "温度57";
CM_ SG_ 2400382542 CSC_Tcell_58_14 "温度58";
CM_ SG_ 2400382542 CSC_Tcell_59_14 "温度59";
CM_ SG_ 2400382542 CSC_Tcell_60_14 "温度60";
CM_ SG_ 2400382542 CSC_Tcell_61_14 "温度61";
CM_ SG_ 2400382542 CSC_Tcell_62_14 "温度62";
CM_ SG_ 2400382542 CSC_Tcell_63_14 "温度63";
CM_ SG_ 2400382542 CSC_Tcell_64_14 "温度64";
CM_ SG_ 2400382542 CSC_Tcell_65_14 "温度65";
CM_ SG_ 2400382542 CSC_Tcell_66_14 "温度66";
CM_ SG_ 2400382542 CSC_Tcell_67_14 "温度67";
CM_ SG_ 2400382542 CSC_Tcell_68_14 "温度68";
CM_ SG_ 2400382542 CSC_Tcell_69_14 "温度69";
CM_ SG_ 2400382542 CSC_Tcell_70_14 "温度70";
CM_ SG_ 2400382542 CSC_Tcell_71_14 "温度71";
CM_ SG_ 2400382542 CSC_Tcell_72_14 "温度72";
CM_ SG_ 2400382543 CSC_T_No_15 "CSC号";
CM_ SG_ 2400382543 CSC_Tcell_Frame_Index_15 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382543 CSC_Tcell_01_15 "温度01";
CM_ SG_ 2400382543 CSC_Tcell_02_15 "温度02";
CM_ SG_ 2400382543 CSC_Tcell_03_15 "温度03";
CM_ SG_ 2400382543 CSC_Tcell_04_15 "温度04";
CM_ SG_ 2400382543 CSC_Tcell_05_15 "温度05";
CM_ SG_ 2400382543 CSC_Tcell_06_15 "温度06";
CM_ SG_ 2400382543 CSC_Tcell_07_15 "温度07";
CM_ SG_ 2400382543 CSC_Tcell_08_15 "温度08";
CM_ SG_ 2400382543 CSC_Tcell_09_15 "温度09";
CM_ SG_ 2400382543 CSC_Tcell_10_15 "温度10";
CM_ SG_ 2400382543 CSC_Tcell_11_15 "温度11";
CM_ SG_ 2400382543 CSC_Tcell_12_15 "温度12";
CM_ SG_ 2400382543 CSC_Tcell_13_15 "温度13";
CM_ SG_ 2400382543 CSC_Tcell_14_15 "温度14";
CM_ SG_ 2400382543 CSC_Tcell_15_15 "温度15";
CM_ SG_ 2400382543 CSC_Tcell_16_15 "温度16";
CM_ SG_ 2400382543 CSC_Tcell_17_15 "温度17";
CM_ SG_ 2400382543 CSC_Tcell_18_15 "温度18";
CM_ SG_ 2400382543 CSC_Tcell_19_15 "温度19";
CM_ SG_ 2400382543 CSC_Tcell_20_15 "温度20";
CM_ SG_ 2400382543 CSC_Tcell_21_15 "温度21";
CM_ SG_ 2400382543 CSC_Tcell_22_15 "温度22";
CM_ SG_ 2400382543 CSC_Tcell_23_15 "温度23";
CM_ SG_ 2400382543 CSC_Tcell_24_15 "温度24";
CM_ SG_ 2400382543 CSC_Tcell_25_15 "温度25";
CM_ SG_ 2400382543 CSC_Tcell_26_15 "温度26";
CM_ SG_ 2400382543 CSC_Tcell_27_15 "温度27";
CM_ SG_ 2400382543 CSC_Tcell_28_15 "温度28";
CM_ SG_ 2400382543 CSC_Tcell_29_15 "温度29";
CM_ SG_ 2400382543 CSC_Tcell_30_15 "温度30";
CM_ SG_ 2400382543 CSC_Tcell_31_15 "温度31";
CM_ SG_ 2400382543 CSC_Tcell_32_15 "温度32";
CM_ SG_ 2400382543 CSC_Tcell_33_15 "温度33";
CM_ SG_ 2400382543 CSC_Tcell_34_15 "温度34";
CM_ SG_ 2400382543 CSC_Tcell_35_15 "温度35";
CM_ SG_ 2400382543 CSC_Tcell_36_15 "温度36";
CM_ SG_ 2400382543 CSC_Tcell_37_15 "温度37";
CM_ SG_ 2400382543 CSC_Tcell_38_15 "温度38";
CM_ SG_ 2400382543 CSC_Tcell_39_15 "温度39";
CM_ SG_ 2400382543 CSC_Tcell_40_15 "温度40";
CM_ SG_ 2400382543 CSC_Tcell_41_15 "温度41";
CM_ SG_ 2400382543 CSC_Tcell_42_15 "温度42";
CM_ SG_ 2400382543 CSC_Tcell_43_15 "温度43";
CM_ SG_ 2400382543 CSC_Tcell_44_15 "温度44";
CM_ SG_ 2400382543 CSC_Tcell_45_15 "温度45";
CM_ SG_ 2400382543 CSC_Tcell_46_15 "温度46";
CM_ SG_ 2400382543 CSC_Tcell_47_15 "温度47";
CM_ SG_ 2400382543 CSC_Tcell_48_15 "温度48";
CM_ SG_ 2400382543 CSC_Tcell_49_15 "温度49";
CM_ SG_ 2400382543 CSC_Tcell_50_15 "温度50";
CM_ SG_ 2400382543 CSC_Tcell_51_15 "温度51";
CM_ SG_ 2400382543 CSC_Tcell_52_15 "温度52";
CM_ SG_ 2400382543 CSC_Tcell_53_15 "温度53";
CM_ SG_ 2400382543 CSC_Tcell_54_15 "温度54";
CM_ SG_ 2400382543 CSC_Tcell_55_15 "温度55";
CM_ SG_ 2400382543 CSC_Tcell_56_15 "温度56";
CM_ SG_ 2400382543 CSC_Tcell_57_15 "温度57";
CM_ SG_ 2400382543 CSC_Tcell_58_15 "温度58";
CM_ SG_ 2400382543 CSC_Tcell_59_15 "温度59";
CM_ SG_ 2400382543 CSC_Tcell_60_15 "温度60";
CM_ SG_ 2400382543 CSC_Tcell_61_15 "温度61";
CM_ SG_ 2400382543 CSC_Tcell_62_15 "温度62";
CM_ SG_ 2400382543 CSC_Tcell_63_15 "温度63";
CM_ SG_ 2400382543 CSC_Tcell_64_15 "温度64";
CM_ SG_ 2400382543 CSC_Tcell_65_15 "温度65";
CM_ SG_ 2400382543 CSC_Tcell_66_15 "温度66";
CM_ SG_ 2400382543 CSC_Tcell_67_15 "温度67";
CM_ SG_ 2400382543 CSC_Tcell_68_15 "温度68";
CM_ SG_ 2400382543 CSC_Tcell_69_15 "温度69";
CM_ SG_ 2400382543 CSC_Tcell_70_15 "温度70";
CM_ SG_ 2400382543 CSC_Tcell_71_15 "温度71";
CM_ SG_ 2400382543 CSC_Tcell_72_15 "温度72";
CM_ SG_ 2400382544 CSC_T_No_16 "CSC号";
CM_ SG_ 2400382544 CSC_Tcell_Frame_Index_16 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382544 CSC_Tcell_01_16 "温度01";
CM_ SG_ 2400382544 CSC_Tcell_02_16 "温度02";
CM_ SG_ 2400382544 CSC_Tcell_03_16 "温度03";
CM_ SG_ 2400382544 CSC_Tcell_04_16 "温度04";
CM_ SG_ 2400382544 CSC_Tcell_05_16 "温度05";
CM_ SG_ 2400382544 CSC_Tcell_06_16 "温度06";
CM_ SG_ 2400382544 CSC_Tcell_07_16 "温度07";
CM_ SG_ 2400382544 CSC_Tcell_08_16 "温度08";
CM_ SG_ 2400382544 CSC_Tcell_09_16 "温度09";
CM_ SG_ 2400382544 CSC_Tcell_10_16 "温度10";
CM_ SG_ 2400382544 CSC_Tcell_11_16 "温度11";
CM_ SG_ 2400382544 CSC_Tcell_12_16 "温度12";
CM_ SG_ 2400382544 CSC_Tcell_13_16 "温度13";
CM_ SG_ 2400382544 CSC_Tcell_14_16 "温度14";
CM_ SG_ 2400382544 CSC_Tcell_15_16 "温度15";
CM_ SG_ 2400382544 CSC_Tcell_16_16 "温度16";
CM_ SG_ 2400382544 CSC_Tcell_17_16 "温度17";
CM_ SG_ 2400382544 CSC_Tcell_18_16 "温度18";
CM_ SG_ 2400382544 CSC_Tcell_19_16 "温度19";
CM_ SG_ 2400382544 CSC_Tcell_20_16 "温度20";
CM_ SG_ 2400382544 CSC_Tcell_21_16 "温度21";
CM_ SG_ 2400382544 CSC_Tcell_22_16 "温度22";
CM_ SG_ 2400382544 CSC_Tcell_23_16 "温度23";
CM_ SG_ 2400382544 CSC_Tcell_24_16 "温度24";
CM_ SG_ 2400382544 CSC_Tcell_25_16 "温度25";
CM_ SG_ 2400382544 CSC_Tcell_26_16 "温度26";
CM_ SG_ 2400382544 CSC_Tcell_27_16 "温度27";
CM_ SG_ 2400382544 CSC_Tcell_28_16 "温度28";
CM_ SG_ 2400382544 CSC_Tcell_29_16 "温度29";
CM_ SG_ 2400382544 CSC_Tcell_30_16 "温度30";
CM_ SG_ 2400382544 CSC_Tcell_31_16 "温度31";
CM_ SG_ 2400382544 CSC_Tcell_32_16 "温度32";
CM_ SG_ 2400382544 CSC_Tcell_33_16 "温度33";
CM_ SG_ 2400382544 CSC_Tcell_34_16 "温度34";
CM_ SG_ 2400382544 CSC_Tcell_35_16 "温度35";
CM_ SG_ 2400382544 CSC_Tcell_36_16 "温度36";
CM_ SG_ 2400382544 CSC_Tcell_37_16 "温度37";
CM_ SG_ 2400382544 CSC_Tcell_38_16 "温度38";
CM_ SG_ 2400382544 CSC_Tcell_39_16 "温度39";
CM_ SG_ 2400382544 CSC_Tcell_40_16 "温度40";
CM_ SG_ 2400382544 CSC_Tcell_41_16 "温度41";
CM_ SG_ 2400382544 CSC_Tcell_42_16 "温度42";
CM_ SG_ 2400382544 CSC_Tcell_43_16 "温度43";
CM_ SG_ 2400382544 CSC_Tcell_44_16 "温度44";
CM_ SG_ 2400382544 CSC_Tcell_45_16 "温度45";
CM_ SG_ 2400382544 CSC_Tcell_46_16 "温度46";
CM_ SG_ 2400382544 CSC_Tcell_47_16 "温度47";
CM_ SG_ 2400382544 CSC_Tcell_48_16 "温度48";
CM_ SG_ 2400382544 CSC_Tcell_49_16 "温度49";
CM_ SG_ 2400382544 CSC_Tcell_50_16 "温度50";
CM_ SG_ 2400382544 CSC_Tcell_51_16 "温度51";
CM_ SG_ 2400382544 CSC_Tcell_52_16 "温度52";
CM_ SG_ 2400382544 CSC_Tcell_53_16 "温度53";
CM_ SG_ 2400382544 CSC_Tcell_54_16 "温度54";
CM_ SG_ 2400382544 CSC_Tcell_55_16 "温度55";
CM_ SG_ 2400382544 CSC_Tcell_56_16 "温度56";
CM_ SG_ 2400382544 CSC_Tcell_57_16 "温度57";
CM_ SG_ 2400382544 CSC_Tcell_58_16 "温度58";
CM_ SG_ 2400382544 CSC_Tcell_59_16 "温度59";
CM_ SG_ 2400382544 CSC_Tcell_60_16 "温度60";
CM_ SG_ 2400382544 CSC_Tcell_61_16 "温度61";
CM_ SG_ 2400382544 CSC_Tcell_62_16 "温度62";
CM_ SG_ 2400382544 CSC_Tcell_63_16 "温度63";
CM_ SG_ 2400382544 CSC_Tcell_64_16 "温度64";
CM_ SG_ 2400382544 CSC_Tcell_65_16 "温度65";
CM_ SG_ 2400382544 CSC_Tcell_66_16 "温度66";
CM_ SG_ 2400382544 CSC_Tcell_67_16 "温度67";
CM_ SG_ 2400382544 CSC_Tcell_68_16 "温度68";
CM_ SG_ 2400382544 CSC_Tcell_69_16 "温度69";
CM_ SG_ 2400382544 CSC_Tcell_70_16 "温度70";
CM_ SG_ 2400382544 CSC_Tcell_71_16 "温度71";
CM_ SG_ 2400382544 CSC_Tcell_72_16 "温度72";
CM_ SG_ 2400382545 CSC_T_No_17 "CSC号";
CM_ SG_ 2400382545 CSC_Tcell_Frame_Index_17 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382545 CSC_Tcell_01_17 "温度01";
CM_ SG_ 2400382545 CSC_Tcell_02_17 "温度02";
CM_ SG_ 2400382545 CSC_Tcell_03_17 "温度03";
CM_ SG_ 2400382545 CSC_Tcell_04_17 "温度04";
CM_ SG_ 2400382545 CSC_Tcell_05_17 "温度05";
CM_ SG_ 2400382545 CSC_Tcell_06_17 "温度06";
CM_ SG_ 2400382545 CSC_Tcell_07_17 "温度07";
CM_ SG_ 2400382545 CSC_Tcell_08_17 "温度08";
CM_ SG_ 2400382545 CSC_Tcell_09_17 "温度09";
CM_ SG_ 2400382545 CSC_Tcell_10_17 "温度10";
CM_ SG_ 2400382545 CSC_Tcell_11_17 "温度11";
CM_ SG_ 2400382545 CSC_Tcell_12_17 "温度12";
CM_ SG_ 2400382545 CSC_Tcell_13_17 "温度13";
CM_ SG_ 2400382545 CSC_Tcell_14_17 "温度14";
CM_ SG_ 2400382545 CSC_Tcell_15_17 "温度15";
CM_ SG_ 2400382545 CSC_Tcell_16_17 "温度16";
CM_ SG_ 2400382545 CSC_Tcell_17_17 "温度17";
CM_ SG_ 2400382545 CSC_Tcell_18_17 "温度18";
CM_ SG_ 2400382545 CSC_Tcell_19_17 "温度19";
CM_ SG_ 2400382545 CSC_Tcell_20_17 "温度20";
CM_ SG_ 2400382545 CSC_Tcell_21_17 "温度21";
CM_ SG_ 2400382545 CSC_Tcell_22_17 "温度22";
CM_ SG_ 2400382545 CSC_Tcell_23_17 "温度23";
CM_ SG_ 2400382545 CSC_Tcell_24_17 "温度24";
CM_ SG_ 2400382545 CSC_Tcell_25_17 "温度25";
CM_ SG_ 2400382545 CSC_Tcell_26_17 "温度26";
CM_ SG_ 2400382545 CSC_Tcell_27_17 "温度27";
CM_ SG_ 2400382545 CSC_Tcell_28_17 "温度28";
CM_ SG_ 2400382545 CSC_Tcell_29_17 "温度29";
CM_ SG_ 2400382545 CSC_Tcell_30_17 "温度30";
CM_ SG_ 2400382545 CSC_Tcell_31_17 "温度31";
CM_ SG_ 2400382545 CSC_Tcell_32_17 "温度32";
CM_ SG_ 2400382545 CSC_Tcell_33_17 "温度33";
CM_ SG_ 2400382545 CSC_Tcell_34_17 "温度34";
CM_ SG_ 2400382545 CSC_Tcell_35_17 "温度35";
CM_ SG_ 2400382545 CSC_Tcell_36_17 "温度36";
CM_ SG_ 2400382545 CSC_Tcell_37_17 "温度37";
CM_ SG_ 2400382545 CSC_Tcell_38_17 "温度38";
CM_ SG_ 2400382545 CSC_Tcell_39_17 "温度39";
CM_ SG_ 2400382545 CSC_Tcell_40_17 "温度40";
CM_ SG_ 2400382545 CSC_Tcell_41_17 "温度41";
CM_ SG_ 2400382545 CSC_Tcell_42_17 "温度42";
CM_ SG_ 2400382545 CSC_Tcell_43_17 "温度43";
CM_ SG_ 2400382545 CSC_Tcell_44_17 "温度44";
CM_ SG_ 2400382545 CSC_Tcell_45_17 "温度45";
CM_ SG_ 2400382545 CSC_Tcell_46_17 "温度46";
CM_ SG_ 2400382545 CSC_Tcell_47_17 "温度47";
CM_ SG_ 2400382545 CSC_Tcell_48_17 "温度48";
CM_ SG_ 2400382545 CSC_Tcell_49_17 "温度49";
CM_ SG_ 2400382545 CSC_Tcell_50_17 "温度50";
CM_ SG_ 2400382545 CSC_Tcell_51_17 "温度51";
CM_ SG_ 2400382545 CSC_Tcell_52_17 "温度52";
CM_ SG_ 2400382545 CSC_Tcell_53_17 "温度53";
CM_ SG_ 2400382545 CSC_Tcell_54_17 "温度54";
CM_ SG_ 2400382545 CSC_Tcell_55_17 "温度55";
CM_ SG_ 2400382545 CSC_Tcell_56_17 "温度56";
CM_ SG_ 2400382545 CSC_Tcell_57_17 "温度57";
CM_ SG_ 2400382545 CSC_Tcell_58_17 "温度58";
CM_ SG_ 2400382545 CSC_Tcell_59_17 "温度59";
CM_ SG_ 2400382545 CSC_Tcell_60_17 "温度60";
CM_ SG_ 2400382545 CSC_Tcell_61_17 "温度61";
CM_ SG_ 2400382545 CSC_Tcell_62_17 "温度62";
CM_ SG_ 2400382545 CSC_Tcell_63_17 "温度63";
CM_ SG_ 2400382545 CSC_Tcell_64_17 "温度64";
CM_ SG_ 2400382545 CSC_Tcell_65_17 "温度65";
CM_ SG_ 2400382545 CSC_Tcell_66_17 "温度66";
CM_ SG_ 2400382545 CSC_Tcell_67_17 "温度67";
CM_ SG_ 2400382545 CSC_Tcell_68_17 "温度68";
CM_ SG_ 2400382545 CSC_Tcell_69_17 "温度69";
CM_ SG_ 2400382545 CSC_Tcell_70_17 "温度70";
CM_ SG_ 2400382545 CSC_Tcell_71_17 "温度71";
CM_ SG_ 2400382545 CSC_Tcell_72_17 "温度72";
CM_ SG_ 2400382546 CSC_T_No_18 "CSC号";
CM_ SG_ 2400382546 CSC_Tcell_Frame_Index_18 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382546 CSC_Tcell_01_18 "温度01";
CM_ SG_ 2400382546 CSC_Tcell_02_18 "温度02";
CM_ SG_ 2400382546 CSC_Tcell_03_18 "温度03";
CM_ SG_ 2400382546 CSC_Tcell_04_18 "温度04";
CM_ SG_ 2400382546 CSC_Tcell_05_18 "温度05";
CM_ SG_ 2400382546 CSC_Tcell_06_18 "温度06";
CM_ SG_ 2400382546 CSC_Tcell_07_18 "温度07";
CM_ SG_ 2400382546 CSC_Tcell_08_18 "温度08";
CM_ SG_ 2400382546 CSC_Tcell_09_18 "温度09";
CM_ SG_ 2400382546 CSC_Tcell_10_18 "温度10";
CM_ SG_ 2400382546 CSC_Tcell_11_18 "温度11";
CM_ SG_ 2400382546 CSC_Tcell_12_18 "温度12";
CM_ SG_ 2400382546 CSC_Tcell_13_18 "温度13";
CM_ SG_ 2400382546 CSC_Tcell_14_18 "温度14";
CM_ SG_ 2400382546 CSC_Tcell_15_18 "温度15";
CM_ SG_ 2400382546 CSC_Tcell_16_18 "温度16";
CM_ SG_ 2400382546 CSC_Tcell_17_18 "温度17";
CM_ SG_ 2400382546 CSC_Tcell_18_18 "温度18";
CM_ SG_ 2400382546 CSC_Tcell_19_18 "温度19";
CM_ SG_ 2400382546 CSC_Tcell_20_18 "温度20";
CM_ SG_ 2400382546 CSC_Tcell_21_18 "温度21";
CM_ SG_ 2400382546 CSC_Tcell_22_18 "温度22";
CM_ SG_ 2400382546 CSC_Tcell_23_18 "温度23";
CM_ SG_ 2400382546 CSC_Tcell_24_18 "温度24";
CM_ SG_ 2400382546 CSC_Tcell_25_18 "温度25";
CM_ SG_ 2400382546 CSC_Tcell_26_18 "温度26";
CM_ SG_ 2400382546 CSC_Tcell_27_18 "温度27";
CM_ SG_ 2400382546 CSC_Tcell_28_18 "温度28";
CM_ SG_ 2400382546 CSC_Tcell_29_18 "温度29";
CM_ SG_ 2400382546 CSC_Tcell_30_18 "温度30";
CM_ SG_ 2400382546 CSC_Tcell_31_18 "温度31";
CM_ SG_ 2400382546 CSC_Tcell_32_18 "温度32";
CM_ SG_ 2400382546 CSC_Tcell_33_18 "温度33";
CM_ SG_ 2400382546 CSC_Tcell_34_18 "温度34";
CM_ SG_ 2400382546 CSC_Tcell_35_18 "温度35";
CM_ SG_ 2400382546 CSC_Tcell_36_18 "温度36";
CM_ SG_ 2400382546 CSC_Tcell_37_18 "温度37";
CM_ SG_ 2400382546 CSC_Tcell_38_18 "温度38";
CM_ SG_ 2400382546 CSC_Tcell_39_18 "温度39";
CM_ SG_ 2400382546 CSC_Tcell_40_18 "温度40";
CM_ SG_ 2400382546 CSC_Tcell_41_18 "温度41";
CM_ SG_ 2400382546 CSC_Tcell_42_18 "温度42";
CM_ SG_ 2400382546 CSC_Tcell_43_18 "温度43";
CM_ SG_ 2400382546 CSC_Tcell_44_18 "温度44";
CM_ SG_ 2400382546 CSC_Tcell_45_18 "温度45";
CM_ SG_ 2400382546 CSC_Tcell_46_18 "温度46";
CM_ SG_ 2400382546 CSC_Tcell_47_18 "温度47";
CM_ SG_ 2400382546 CSC_Tcell_48_18 "温度48";
CM_ SG_ 2400382546 CSC_Tcell_49_18 "温度49";
CM_ SG_ 2400382546 CSC_Tcell_50_18 "温度50";
CM_ SG_ 2400382546 CSC_Tcell_51_18 "温度51";
CM_ SG_ 2400382546 CSC_Tcell_52_18 "温度52";
CM_ SG_ 2400382546 CSC_Tcell_53_18 "温度53";
CM_ SG_ 2400382546 CSC_Tcell_54_18 "温度54";
CM_ SG_ 2400382546 CSC_Tcell_55_18 "温度55";
CM_ SG_ 2400382546 CSC_Tcell_56_18 "温度56";
CM_ SG_ 2400382546 CSC_Tcell_57_18 "温度57";
CM_ SG_ 2400382546 CSC_Tcell_58_18 "温度58";
CM_ SG_ 2400382546 CSC_Tcell_59_18 "温度59";
CM_ SG_ 2400382546 CSC_Tcell_60_18 "温度60";
CM_ SG_ 2400382546 CSC_Tcell_61_18 "温度61";
CM_ SG_ 2400382546 CSC_Tcell_62_18 "温度62";
CM_ SG_ 2400382546 CSC_Tcell_63_18 "温度63";
CM_ SG_ 2400382546 CSC_Tcell_64_18 "温度64";
CM_ SG_ 2400382546 CSC_Tcell_65_18 "温度65";
CM_ SG_ 2400382546 CSC_Tcell_66_18 "温度66";
CM_ SG_ 2400382546 CSC_Tcell_67_18 "温度67";
CM_ SG_ 2400382546 CSC_Tcell_68_18 "温度68";
CM_ SG_ 2400382546 CSC_Tcell_69_18 "温度69";
CM_ SG_ 2400382546 CSC_Tcell_70_18 "温度70";
CM_ SG_ 2400382546 CSC_Tcell_71_18 "温度71";
CM_ SG_ 2400382546 CSC_Tcell_72_18 "温度72";
CM_ SG_ 2400382547 CSC_T_No_19 "CSC号";
CM_ SG_ 2400382547 CSC_Tcell_Frame_Index_19 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382547 CSC_Tcell_01_19 "温度01";
CM_ SG_ 2400382547 CSC_Tcell_02_19 "温度02";
CM_ SG_ 2400382547 CSC_Tcell_03_19 "温度03";
CM_ SG_ 2400382547 CSC_Tcell_04_19 "温度04";
CM_ SG_ 2400382547 CSC_Tcell_05_19 "温度05";
CM_ SG_ 2400382547 CSC_Tcell_06_19 "温度06";
CM_ SG_ 2400382547 CSC_Tcell_07_19 "温度07";
CM_ SG_ 2400382547 CSC_Tcell_08_19 "温度08";
CM_ SG_ 2400382547 CSC_Tcell_09_19 "温度09";
CM_ SG_ 2400382547 CSC_Tcell_10_19 "温度10";
CM_ SG_ 2400382547 CSC_Tcell_11_19 "温度11";
CM_ SG_ 2400382547 CSC_Tcell_12_19 "温度12";
CM_ SG_ 2400382547 CSC_Tcell_13_19 "温度13";
CM_ SG_ 2400382547 CSC_Tcell_14_19 "温度14";
CM_ SG_ 2400382547 CSC_Tcell_15_19 "温度15";
CM_ SG_ 2400382547 CSC_Tcell_16_19 "温度16";
CM_ SG_ 2400382547 CSC_Tcell_17_19 "温度17";
CM_ SG_ 2400382547 CSC_Tcell_18_19 "温度18";
CM_ SG_ 2400382547 CSC_Tcell_19_19 "温度19";
CM_ SG_ 2400382547 CSC_Tcell_20_19 "温度20";
CM_ SG_ 2400382547 CSC_Tcell_21_19 "温度21";
CM_ SG_ 2400382547 CSC_Tcell_22_19 "温度22";
CM_ SG_ 2400382547 CSC_Tcell_23_19 "温度23";
CM_ SG_ 2400382547 CSC_Tcell_24_19 "温度24";
CM_ SG_ 2400382547 CSC_Tcell_25_19 "温度25";
CM_ SG_ 2400382547 CSC_Tcell_26_19 "温度26";
CM_ SG_ 2400382547 CSC_Tcell_27_19 "温度27";
CM_ SG_ 2400382547 CSC_Tcell_28_19 "温度28";
CM_ SG_ 2400382547 CSC_Tcell_29_19 "温度29";
CM_ SG_ 2400382547 CSC_Tcell_30_19 "温度30";
CM_ SG_ 2400382547 CSC_Tcell_31_19 "温度31";
CM_ SG_ 2400382547 CSC_Tcell_32_19 "温度32";
CM_ SG_ 2400382547 CSC_Tcell_33_19 "温度33";
CM_ SG_ 2400382547 CSC_Tcell_34_19 "温度34";
CM_ SG_ 2400382547 CSC_Tcell_35_19 "温度35";
CM_ SG_ 2400382547 CSC_Tcell_36_19 "温度36";
CM_ SG_ 2400382547 CSC_Tcell_37_19 "温度37";
CM_ SG_ 2400382547 CSC_Tcell_38_19 "温度38";
CM_ SG_ 2400382547 CSC_Tcell_39_19 "温度39";
CM_ SG_ 2400382547 CSC_Tcell_40_19 "温度40";
CM_ SG_ 2400382547 CSC_Tcell_41_19 "温度41";
CM_ SG_ 2400382547 CSC_Tcell_42_19 "温度42";
CM_ SG_ 2400382547 CSC_Tcell_43_19 "温度43";
CM_ SG_ 2400382547 CSC_Tcell_44_19 "温度44";
CM_ SG_ 2400382547 CSC_Tcell_45_19 "温度45";
CM_ SG_ 2400382547 CSC_Tcell_46_19 "温度46";
CM_ SG_ 2400382547 CSC_Tcell_47_19 "温度47";
CM_ SG_ 2400382547 CSC_Tcell_48_19 "温度48";
CM_ SG_ 2400382547 CSC_Tcell_49_19 "温度49";
CM_ SG_ 2400382547 CSC_Tcell_50_19 "温度50";
CM_ SG_ 2400382547 CSC_Tcell_51_19 "温度51";
CM_ SG_ 2400382547 CSC_Tcell_52_19 "温度52";
CM_ SG_ 2400382547 CSC_Tcell_53_19 "温度53";
CM_ SG_ 2400382547 CSC_Tcell_54_19 "温度54";
CM_ SG_ 2400382547 CSC_Tcell_55_19 "温度55";
CM_ SG_ 2400382547 CSC_Tcell_56_19 "温度56";
CM_ SG_ 2400382547 CSC_Tcell_57_19 "温度57";
CM_ SG_ 2400382547 CSC_Tcell_58_19 "温度58";
CM_ SG_ 2400382547 CSC_Tcell_59_19 "温度59";
CM_ SG_ 2400382547 CSC_Tcell_60_19 "温度60";
CM_ SG_ 2400382547 CSC_Tcell_61_19 "温度61";
CM_ SG_ 2400382547 CSC_Tcell_62_19 "温度62";
CM_ SG_ 2400382547 CSC_Tcell_63_19 "温度63";
CM_ SG_ 2400382547 CSC_Tcell_64_19 "温度64";
CM_ SG_ 2400382547 CSC_Tcell_65_19 "温度65";
CM_ SG_ 2400382547 CSC_Tcell_66_19 "温度66";
CM_ SG_ 2400382547 CSC_Tcell_67_19 "温度67";
CM_ SG_ 2400382547 CSC_Tcell_68_19 "温度68";
CM_ SG_ 2400382547 CSC_Tcell_69_19 "温度69";
CM_ SG_ 2400382547 CSC_Tcell_70_19 "温度70";
CM_ SG_ 2400382547 CSC_Tcell_71_19 "温度71";
CM_ SG_ 2400382547 CSC_Tcell_72_19 "温度72";
CM_ SG_ 2400382548 CSC_T_No_20 "CSC号";
CM_ SG_ 2400382548 CSC_Tcell_Frame_Index_20 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382548 CSC_Tcell_01_20 "温度01";
CM_ SG_ 2400382548 CSC_Tcell_02_20 "温度02";
CM_ SG_ 2400382548 CSC_Tcell_03_20 "温度03";
CM_ SG_ 2400382548 CSC_Tcell_04_20 "温度04";
CM_ SG_ 2400382548 CSC_Tcell_05_20 "温度05";
CM_ SG_ 2400382548 CSC_Tcell_06_20 "温度06";
CM_ SG_ 2400382548 CSC_Tcell_07_20 "温度07";
CM_ SG_ 2400382548 CSC_Tcell_08_20 "温度08";
CM_ SG_ 2400382548 CSC_Tcell_09_20 "温度09";
CM_ SG_ 2400382548 CSC_Tcell_10_20 "温度10";
CM_ SG_ 2400382548 CSC_Tcell_11_20 "温度11";
CM_ SG_ 2400382548 CSC_Tcell_12_20 "温度12";
CM_ SG_ 2400382548 CSC_Tcell_13_20 "温度13";
CM_ SG_ 2400382548 CSC_Tcell_14_20 "温度14";
CM_ SG_ 2400382548 CSC_Tcell_15_20 "温度15";
CM_ SG_ 2400382548 CSC_Tcell_16_20 "温度16";
CM_ SG_ 2400382548 CSC_Tcell_17_20 "温度17";
CM_ SG_ 2400382548 CSC_Tcell_18_20 "温度18";
CM_ SG_ 2400382548 CSC_Tcell_19_20 "温度19";
CM_ SG_ 2400382548 CSC_Tcell_20_20 "温度20";
CM_ SG_ 2400382548 CSC_Tcell_21_20 "温度21";
CM_ SG_ 2400382548 CSC_Tcell_22_20 "温度22";
CM_ SG_ 2400382548 CSC_Tcell_23_20 "温度23";
CM_ SG_ 2400382548 CSC_Tcell_24_20 "温度24";
CM_ SG_ 2400382548 CSC_Tcell_25_20 "温度25";
CM_ SG_ 2400382548 CSC_Tcell_26_20 "温度26";
CM_ SG_ 2400382548 CSC_Tcell_27_20 "温度27";
CM_ SG_ 2400382548 CSC_Tcell_28_20 "温度28";
CM_ SG_ 2400382548 CSC_Tcell_29_20 "温度29";
CM_ SG_ 2400382548 CSC_Tcell_30_20 "温度30";
CM_ SG_ 2400382548 CSC_Tcell_31_20 "温度31";
CM_ SG_ 2400382548 CSC_Tcell_32_20 "温度32";
CM_ SG_ 2400382548 CSC_Tcell_33_20 "温度33";
CM_ SG_ 2400382548 CSC_Tcell_34_20 "温度34";
CM_ SG_ 2400382548 CSC_Tcell_35_20 "温度35";
CM_ SG_ 2400382548 CSC_Tcell_36_20 "温度36";
CM_ SG_ 2400382548 CSC_Tcell_37_20 "温度37";
CM_ SG_ 2400382548 CSC_Tcell_38_20 "温度38";
CM_ SG_ 2400382548 CSC_Tcell_39_20 "温度39";
CM_ SG_ 2400382548 CSC_Tcell_40_20 "温度40";
CM_ SG_ 2400382548 CSC_Tcell_41_20 "温度41";
CM_ SG_ 2400382548 CSC_Tcell_42_20 "温度42";
CM_ SG_ 2400382548 CSC_Tcell_43_20 "温度43";
CM_ SG_ 2400382548 CSC_Tcell_44_20 "温度44";
CM_ SG_ 2400382548 CSC_Tcell_45_20 "温度45";
CM_ SG_ 2400382548 CSC_Tcell_46_20 "温度46";
CM_ SG_ 2400382548 CSC_Tcell_47_20 "温度47";
CM_ SG_ 2400382548 CSC_Tcell_48_20 "温度48";
CM_ SG_ 2400382548 CSC_Tcell_49_20 "温度49";
CM_ SG_ 2400382548 CSC_Tcell_50_20 "温度50";
CM_ SG_ 2400382548 CSC_Tcell_51_20 "温度51";
CM_ SG_ 2400382548 CSC_Tcell_52_20 "温度52";
CM_ SG_ 2400382548 CSC_Tcell_53_20 "温度53";
CM_ SG_ 2400382548 CSC_Tcell_54_20 "温度54";
CM_ SG_ 2400382548 CSC_Tcell_55_20 "温度55";
CM_ SG_ 2400382548 CSC_Tcell_56_20 "温度56";
CM_ SG_ 2400382548 CSC_Tcell_57_20 "温度57";
CM_ SG_ 2400382548 CSC_Tcell_58_20 "温度58";
CM_ SG_ 2400382548 CSC_Tcell_59_20 "温度59";
CM_ SG_ 2400382548 CSC_Tcell_60_20 "温度60";
CM_ SG_ 2400382548 CSC_Tcell_61_20 "温度61";
CM_ SG_ 2400382548 CSC_Tcell_62_20 "温度62";
CM_ SG_ 2400382548 CSC_Tcell_63_20 "温度63";
CM_ SG_ 2400382548 CSC_Tcell_64_20 "温度64";
CM_ SG_ 2400382548 CSC_Tcell_65_20 "温度65";
CM_ SG_ 2400382548 CSC_Tcell_66_20 "温度66";
CM_ SG_ 2400382548 CSC_Tcell_67_20 "温度67";
CM_ SG_ 2400382548 CSC_Tcell_68_20 "温度68";
CM_ SG_ 2400382548 CSC_Tcell_69_20 "温度69";
CM_ SG_ 2400382548 CSC_Tcell_70_20 "温度70";
CM_ SG_ 2400382548 CSC_Tcell_71_20 "温度71";
CM_ SG_ 2400382548 CSC_Tcell_72_20 "温度72";
VAL_ 2400382532 CSC_T_No_04 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382532 CSC_Tcell_01_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_02_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_03_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_04_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_05_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_06_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_07_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_08_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_09_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_10_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_11_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_12_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_13_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_14_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_15_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_16_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_17_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_18_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_19_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_20_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_21_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_22_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_23_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_24_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_25_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_26_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_27_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_28_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_29_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_30_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_31_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_32_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_33_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_34_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_35_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_36_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_37_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_38_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_39_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_40_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_41_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_42_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_43_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_44_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_45_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_46_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_47_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_48_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_49_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_50_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_51_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_52_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_53_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_54_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_55_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_56_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_57_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_58_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_59_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_60_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_61_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_62_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_63_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_64_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_65_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_66_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_67_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_68_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_69_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_70_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_71_04 255 "Invalid" ;
VAL_ 2400382532 CSC_Tcell_72_04 255 "Invalid" ;
VAL_ 2400382533 CSC_T_No_05 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382533 CSC_Tcell_01_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_02_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_03_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_04_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_05_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_06_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_07_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_08_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_09_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_10_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_11_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_12_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_13_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_14_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_15_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_16_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_17_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_18_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_19_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_20_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_21_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_22_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_23_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_24_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_25_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_26_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_27_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_28_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_29_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_30_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_31_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_32_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_33_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_34_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_35_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_36_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_37_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_38_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_39_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_40_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_41_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_42_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_43_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_44_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_45_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_46_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_47_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_48_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_49_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_50_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_51_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_52_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_53_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_54_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_55_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_56_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_57_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_58_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_59_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_60_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_61_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_62_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_63_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_64_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_65_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_66_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_67_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_68_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_69_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_70_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_71_05 255 "Invalid" ;
VAL_ 2400382533 CSC_Tcell_72_05 255 "Invalid" ;
VAL_ 2400382534 CSC_T_No_06 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382534 CSC_Tcell_01_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_02_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_03_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_04_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_05_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_06_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_07_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_08_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_09_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_10_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_11_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_12_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_13_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_14_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_15_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_16_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_17_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_18_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_19_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_20_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_21_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_22_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_23_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_24_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_25_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_26_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_27_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_28_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_29_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_30_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_31_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_32_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_33_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_34_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_35_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_36_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_37_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_38_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_39_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_40_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_41_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_42_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_43_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_44_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_45_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_46_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_47_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_48_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_49_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_50_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_51_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_52_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_53_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_54_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_55_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_56_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_57_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_58_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_59_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_60_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_61_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_62_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_63_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_64_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_65_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_66_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_67_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_68_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_69_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_70_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_71_06 255 "Invalid" ;
VAL_ 2400382534 CSC_Tcell_72_06 255 "Invalid" ;
VAL_ 2400382535 CSC_T_No_07 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382535 CSC_Tcell_01_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_02_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_03_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_04_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_05_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_06_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_07_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_08_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_09_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_10_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_11_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_12_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_13_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_14_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_15_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_16_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_17_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_18_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_19_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_20_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_21_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_22_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_23_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_24_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_25_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_26_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_27_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_28_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_29_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_30_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_31_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_32_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_33_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_34_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_35_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_36_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_37_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_38_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_39_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_40_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_41_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_42_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_43_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_44_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_45_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_46_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_47_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_48_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_49_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_50_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_51_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_52_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_53_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_54_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_55_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_56_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_57_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_58_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_59_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_60_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_61_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_62_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_63_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_64_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_65_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_66_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_67_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_68_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_69_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_70_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_71_07 255 "Invalid" ;
VAL_ 2400382535 CSC_Tcell_72_07 255 "Invalid" ;
VAL_ 2400382536 CSC_T_No_08 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382536 CSC_Tcell_01_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_02_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_03_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_04_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_05_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_06_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_07_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_08_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_09_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_10_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_11_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_12_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_13_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_14_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_15_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_16_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_17_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_18_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_19_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_20_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_21_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_22_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_23_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_24_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_25_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_26_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_27_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_28_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_29_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_30_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_31_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_32_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_33_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_34_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_35_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_36_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_37_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_38_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_39_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_40_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_41_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_42_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_43_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_44_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_45_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_46_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_47_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_48_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_49_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_50_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_51_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_52_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_53_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_54_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_55_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_56_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_57_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_58_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_59_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_60_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_61_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_62_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_63_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_64_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_65_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_66_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_67_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_68_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_69_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_70_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_71_08 255 "Invalid" ;
VAL_ 2400382536 CSC_Tcell_72_08 255 "Invalid" ;
VAL_ 2400382537 CSC_T_No_09 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382537 CSC_Tcell_01_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_02_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_03_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_04_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_05_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_06_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_07_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_08_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_09_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_10_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_11_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_12_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_13_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_14_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_15_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_16_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_17_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_18_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_19_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_20_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_21_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_22_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_23_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_24_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_25_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_26_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_27_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_28_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_29_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_30_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_31_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_32_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_33_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_34_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_35_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_36_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_37_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_38_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_39_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_40_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_41_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_42_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_43_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_44_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_45_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_46_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_47_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_48_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_49_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_50_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_51_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_52_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_53_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_54_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_55_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_56_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_57_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_58_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_59_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_60_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_61_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_62_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_63_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_64_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_65_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_66_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_67_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_68_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_69_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_70_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_71_09 255 "Invalid" ;
VAL_ 2400382537 CSC_Tcell_72_09 255 "Invalid" ;
VAL_ 2400382538 CSC_T_No_10 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382538 CSC_Tcell_01_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_02_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_03_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_04_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_05_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_06_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_07_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_08_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_09_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_10_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_11_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_12_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_13_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_14_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_15_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_16_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_17_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_18_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_19_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_20_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_21_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_22_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_23_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_24_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_25_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_26_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_27_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_28_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_29_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_30_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_31_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_32_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_33_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_34_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_35_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_36_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_37_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_38_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_39_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_40_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_41_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_42_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_43_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_44_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_45_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_46_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_47_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_48_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_49_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_50_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_51_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_52_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_53_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_54_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_55_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_56_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_57_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_58_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_59_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_60_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_61_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_62_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_63_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_64_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_65_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_66_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_67_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_68_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_69_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_70_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_71_10 255 "Invalid" ;
VAL_ 2400382538 CSC_Tcell_72_10 255 "Invalid" ;
VAL_ 2400382539 CSC_T_No_11 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382539 CSC_Tcell_01_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_02_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_03_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_04_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_05_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_06_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_07_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_08_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_09_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_10_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_11_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_12_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_13_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_14_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_15_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_16_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_17_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_18_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_19_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_20_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_21_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_22_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_23_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_24_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_25_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_26_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_27_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_28_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_29_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_30_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_31_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_32_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_33_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_34_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_35_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_36_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_37_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_38_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_39_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_40_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_41_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_42_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_43_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_44_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_45_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_46_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_47_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_48_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_49_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_50_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_51_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_52_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_53_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_54_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_55_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_56_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_57_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_58_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_59_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_60_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_61_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_62_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_63_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_64_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_65_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_66_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_67_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_68_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_69_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_70_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_71_11 255 "Invalid" ;
VAL_ 2400382539 CSC_Tcell_72_11 255 "Invalid" ;
VAL_ 2400382540 CSC_T_No_12 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382540 CSC_Tcell_01_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_02_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_03_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_04_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_05_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_06_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_07_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_08_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_09_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_10_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_11_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_12_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_13_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_14_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_15_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_16_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_17_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_18_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_19_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_20_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_21_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_22_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_23_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_24_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_25_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_26_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_27_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_28_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_29_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_30_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_31_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_32_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_33_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_34_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_35_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_36_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_37_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_38_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_39_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_40_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_41_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_42_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_43_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_44_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_45_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_46_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_47_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_48_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_49_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_50_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_51_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_52_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_53_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_54_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_55_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_56_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_57_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_58_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_59_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_60_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_61_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_62_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_63_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_64_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_65_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_66_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_67_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_68_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_69_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_70_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_71_12 255 "Invalid" ;
VAL_ 2400382540 CSC_Tcell_72_12 255 "Invalid" ;
VAL_ 2400382541 CSC_T_No_13 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382541 CSC_Tcell_01_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_02_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_03_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_04_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_05_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_06_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_07_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_08_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_09_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_10_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_11_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_12_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_13_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_14_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_15_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_16_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_17_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_18_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_19_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_20_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_21_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_22_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_23_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_24_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_25_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_26_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_27_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_28_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_29_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_30_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_31_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_32_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_33_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_34_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_35_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_36_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_37_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_38_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_39_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_40_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_41_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_42_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_43_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_44_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_45_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_46_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_47_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_48_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_49_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_50_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_51_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_52_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_53_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_54_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_55_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_56_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_57_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_58_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_59_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_60_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_61_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_62_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_63_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_64_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_65_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_66_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_67_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_68_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_69_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_70_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_71_13 255 "Invalid" ;
VAL_ 2400382541 CSC_Tcell_72_13 255 "Invalid" ;
VAL_ 2400382542 CSC_T_No_14 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382542 CSC_Tcell_01_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_02_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_03_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_04_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_05_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_06_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_07_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_08_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_09_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_10_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_11_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_12_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_13_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_14_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_15_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_16_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_17_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_18_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_19_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_20_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_21_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_22_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_23_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_24_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_25_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_26_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_27_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_28_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_29_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_30_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_31_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_32_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_33_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_34_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_35_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_36_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_37_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_38_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_39_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_40_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_41_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_42_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_43_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_44_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_45_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_46_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_47_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_48_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_49_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_50_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_51_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_52_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_53_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_54_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_55_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_56_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_57_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_58_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_59_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_60_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_61_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_62_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_63_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_64_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_65_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_66_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_67_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_68_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_69_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_70_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_71_14 255 "Invalid" ;
VAL_ 2400382542 CSC_Tcell_72_14 255 "Invalid" ;
VAL_ 2400382543 CSC_T_No_15 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382543 CSC_Tcell_01_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_02_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_03_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_04_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_05_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_06_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_07_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_08_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_09_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_10_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_11_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_12_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_13_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_14_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_15_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_16_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_17_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_18_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_19_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_20_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_21_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_22_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_23_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_24_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_25_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_26_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_27_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_28_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_29_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_30_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_31_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_32_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_33_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_34_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_35_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_36_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_37_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_38_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_39_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_40_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_41_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_42_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_43_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_44_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_45_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_46_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_47_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_48_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_49_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_50_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_51_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_52_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_53_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_54_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_55_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_56_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_57_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_58_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_59_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_60_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_61_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_62_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_63_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_64_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_65_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_66_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_67_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_68_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_69_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_70_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_71_15 255 "Invalid" ;
VAL_ 2400382543 CSC_Tcell_72_15 255 "Invalid" ;
VAL_ 2400382544 CSC_T_No_16 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382544 CSC_Tcell_01_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_02_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_03_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_04_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_05_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_06_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_07_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_08_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_09_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_10_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_11_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_12_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_13_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_14_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_15_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_16_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_17_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_18_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_19_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_20_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_21_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_22_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_23_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_24_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_25_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_26_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_27_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_28_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_29_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_30_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_31_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_32_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_33_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_34_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_35_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_36_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_37_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_38_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_39_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_40_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_41_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_42_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_43_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_44_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_45_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_46_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_47_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_48_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_49_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_50_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_51_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_52_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_53_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_54_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_55_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_56_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_57_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_58_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_59_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_60_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_61_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_62_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_63_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_64_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_65_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_66_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_67_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_68_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_69_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_70_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_71_16 255 "Invalid" ;
VAL_ 2400382544 CSC_Tcell_72_16 255 "Invalid" ;
VAL_ 2400382545 CSC_T_No_17 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382545 CSC_Tcell_01_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_02_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_03_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_04_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_05_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_06_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_07_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_08_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_09_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_10_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_11_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_12_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_13_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_14_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_15_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_16_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_17_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_18_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_19_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_20_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_21_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_22_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_23_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_24_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_25_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_26_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_27_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_28_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_29_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_30_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_31_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_32_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_33_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_34_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_35_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_36_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_37_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_38_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_39_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_40_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_41_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_42_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_43_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_44_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_45_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_46_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_47_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_48_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_49_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_50_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_51_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_52_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_53_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_54_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_55_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_56_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_57_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_58_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_59_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_60_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_61_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_62_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_63_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_64_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_65_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_66_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_67_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_68_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_69_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_70_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_71_17 255 "Invalid" ;
VAL_ 2400382545 CSC_Tcell_72_17 255 "Invalid" ;
VAL_ 2400382546 CSC_T_No_18 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382546 CSC_Tcell_01_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_02_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_03_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_04_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_05_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_06_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_07_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_08_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_09_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_10_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_11_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_12_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_13_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_14_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_15_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_16_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_17_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_18_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_19_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_20_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_21_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_22_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_23_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_24_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_25_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_26_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_27_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_28_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_29_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_30_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_31_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_32_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_33_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_34_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_35_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_36_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_37_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_38_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_39_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_40_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_41_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_42_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_43_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_44_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_45_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_46_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_47_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_48_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_49_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_50_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_51_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_52_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_53_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_54_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_55_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_56_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_57_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_58_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_59_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_60_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_61_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_62_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_63_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_64_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_65_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_66_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_67_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_68_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_69_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_70_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_71_18 255 "Invalid" ;
VAL_ 2400382546 CSC_Tcell_72_18 255 "Invalid" ;
VAL_ 2400382547 CSC_T_No_19 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382547 CSC_Tcell_01_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_02_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_03_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_04_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_05_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_06_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_07_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_08_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_09_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_10_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_11_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_12_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_13_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_14_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_15_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_16_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_17_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_18_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_19_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_20_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_21_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_22_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_23_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_24_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_25_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_26_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_27_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_28_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_29_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_30_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_31_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_32_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_33_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_34_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_35_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_36_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_37_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_38_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_39_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_40_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_41_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_42_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_43_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_44_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_45_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_46_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_47_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_48_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_49_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_50_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_51_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_52_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_53_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_54_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_55_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_56_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_57_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_58_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_59_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_60_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_61_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_62_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_63_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_64_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_65_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_66_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_67_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_68_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_69_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_70_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_71_19 255 "Invalid" ;
VAL_ 2400382547 CSC_Tcell_72_19 255 "Invalid" ;
VAL_ 2400382548 CSC_T_No_20 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382548 CSC_Tcell_01_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_02_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_03_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_04_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_05_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_06_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_07_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_08_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_09_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_10_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_11_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_12_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_13_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_14_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_15_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_16_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_17_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_18_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_19_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_20_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_21_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_22_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_23_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_24_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_25_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_26_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_27_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_28_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_29_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_30_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_31_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_32_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_33_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_34_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_35_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_36_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_37_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_38_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_39_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_40_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_41_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_42_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_43_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_44_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_45_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_46_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_47_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_48_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_49_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_50_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_51_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_52_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_53_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_54_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_55_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_56_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_57_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_58_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_59_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_60_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_61_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_62_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_63_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_64_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_65_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_66_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_67_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_68_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_69_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_70_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_71_20 255 "Invalid" ;
VAL_ 2400382548 CSC_Tcell_72_20 255 "Invalid" ;
