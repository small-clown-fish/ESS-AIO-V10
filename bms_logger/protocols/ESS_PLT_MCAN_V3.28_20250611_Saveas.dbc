VERSION ""

NS_ :

BS_:

BU_: MBMU PC SBMU IMM ETH DCDC LEMS

BO_ 2400317000 S2P_Detail_Ucell1__08: 8 SBMU
 SG_ CSC_U_No_08 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_08 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_08 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_08 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_08 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_08 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_08 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_08 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_08 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_08 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_08 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_08 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_08 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_08 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_08 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_08 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_08 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_08 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_08 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_08 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_08 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_08 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_08 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_08 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_08 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_08 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_08 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_08 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_08 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_08 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_08 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_08 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_08 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_08 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_08 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_08 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_08 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_08 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_08 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_08 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_08 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_08 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_08 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_08 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_08 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_08 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_08 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_08 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_08 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_08 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_08 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_08 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_08 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_08 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_08 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_08 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_08 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_08 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_08 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317001 S2P_Detail_Ucell1__09: 8 SBMU
 SG_ CSC_U_No_09 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_09 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_09 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_09 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_09 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_09 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_09 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_09 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_09 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_09 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_09 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_09 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_09 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_09 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_09 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_09 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_09 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_09 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_09 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_09 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_09 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_09 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_09 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_09 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_09 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_09 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_09 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_09 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_09 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_09 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_09 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_09 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_09 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_09 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_09 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_09 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_09 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_09 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_09 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_09 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_09 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_09 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_09 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_09 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_09 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_09 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_09 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_09 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_09 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_09 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_09 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_09 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_09 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_09 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_09 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_09 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_09 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_09 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_09 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317002 S2P_Detail_Ucell1__10: 8 SBMU
 SG_ CSC_U_No_10 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_10 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_10 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_10 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_10 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_10 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_10 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_10 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_10 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_10 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_10 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_10 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_10 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_10 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_10 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_10 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_10 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_10 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_10 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_10 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_10 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_10 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_10 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_10 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_10 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_10 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_10 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_10 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_10 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_10 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_10 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_10 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_10 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_10 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_10 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_10 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_10 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_10 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_10 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_10 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_10 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_10 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_10 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_10 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_10 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_10 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_10 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_10 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_10 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_10 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_10 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_10 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_10 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_10 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_10 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_10 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_10 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_10 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_10 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317003 S2P_Detail_Ucell1__11: 8 SBMU
 SG_ CSC_U_No_11 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_11 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_11 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_11 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_11 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_11 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_11 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_11 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_11 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_11 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_11 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_11 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_11 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_11 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_11 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_11 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_11 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_11 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_11 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_11 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_11 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_11 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_11 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_11 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_11 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_11 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_11 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_11 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_11 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_11 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_11 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_11 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_11 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_11 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_11 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_11 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_11 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_11 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_11 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_11 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_11 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_11 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_11 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_11 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_11 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_11 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_11 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_11 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_11 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_11 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_11 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_11 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_11 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_11 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_11 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_11 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_11 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_11 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_11 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317004 S2P_Detail_Ucell1__12: 8 SBMU
 SG_ CSC_U_No_12 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_12 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_12 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_12 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_12 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_12 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_12 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_12 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_12 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_12 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_12 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_12 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_12 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_12 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_12 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_12 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_12 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_12 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_12 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_12 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_12 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_12 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_12 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_12 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_12 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_12 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_12 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_12 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_12 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_12 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_12 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_12 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_12 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_12 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_12 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_12 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_12 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_12 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_12 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_12 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_12 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_12 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_12 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_12 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_12 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_12 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_12 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_12 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_12 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_12 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_12 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_12 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_12 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_12 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_12 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_12 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_12 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_12 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_12 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317005 S2P_Detail_Ucell1__13: 8 SBMU
 SG_ CSC_U_No_13 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_13 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_13 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_13 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_13 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_13 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_13 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_13 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_13 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_13 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_13 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_13 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_13 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_13 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_13 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_13 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_13 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_13 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_13 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_13 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_13 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_13 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_13 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_13 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_13 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_13 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_13 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_13 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_13 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_13 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_13 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_13 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_13 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_13 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_13 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_13 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_13 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_13 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_13 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_13 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_13 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_13 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_13 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_13 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_13 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_13 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_13 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_13 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_13 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_13 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_13 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_13 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_13 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_13 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_13 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_13 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_13 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_13 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_13 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317006 S2P_Detail_Ucell1__14: 8 SBMU
 SG_ CSC_U_No_14 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_14 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_14 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_14 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_14 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_14 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_14 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_14 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_14 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_14 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_14 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_14 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_14 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_14 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_14 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_14 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_14 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_14 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_14 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_14 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_14 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_14 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_14 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_14 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_14 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_14 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_14 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_14 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_14 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_14 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_14 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_14 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_14 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_14 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_14 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_14 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_14 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_14 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_14 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_14 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_14 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_14 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_14 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_14 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_14 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_14 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_14 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_14 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_14 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_14 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_14 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_14 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_14 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_14 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_14 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_14 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_14 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_14 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_14 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317007 S2P_Detail_Ucell1__15: 8 SBMU
 SG_ CSC_U_No_15 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_15 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_15 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_15 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_15 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_15 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_15 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_15 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_15 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_15 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_15 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_15 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_15 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_15 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_15 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_15 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_15 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_15 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_15 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_15 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_15 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_15 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_15 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_15 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_15 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_15 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_15 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_15 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_15 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_15 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_15 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_15 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_15 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_15 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_15 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_15 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_15 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_15 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_15 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_15 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_15 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_15 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_15 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_15 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_15 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_15 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_15 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_15 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_15 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_15 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_15 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_15 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_15 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_15 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_15 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_15 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_15 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_15 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_15 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317008 S2P_Detail_Ucell1__16: 8 SBMU
 SG_ CSC_U_No_16 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_16 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_16 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_16 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_16 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_16 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_16 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_16 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_16 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_16 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_16 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_16 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_16 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_16 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_16 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_16 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_16 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_16 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_16 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_16 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_16 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_16 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_16 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_16 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_16 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_16 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_16 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_16 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_16 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_16 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_16 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_16 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_16 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_16 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_16 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_16 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_16 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_16 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_16 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_16 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_16 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_16 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_16 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_16 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_16 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_16 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_16 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_16 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_16 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_16 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_16 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_16 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_16 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_16 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_16 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_16 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_16 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_16 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_16 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317009 S2P_Detail_Ucell1__17: 8 SBMU
 SG_ CSC_U_No_17 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_17 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_17 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_17 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_17 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_17 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_17 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_17 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_17 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_17 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_17 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_17 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_17 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_17 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_17 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_17 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_17 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_17 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_17 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_17 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_17 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_17 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_17 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_17 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_17 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_17 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_17 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_17 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_17 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_17 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_17 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_17 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_17 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_17 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_17 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_17 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_17 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_17 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_17 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_17 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_17 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_17 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_17 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_17 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_17 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_17 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_17 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_17 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_17 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_17 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_17 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_17 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_17 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_17 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_17 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_17 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_17 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_17 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_17 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317010 S2P_Detail_Ucell1__18: 8 SBMU
 SG_ CSC_U_No_18 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_18 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_18 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_18 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_18 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_18 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_18 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_18 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_18 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_18 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_18 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_18 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_18 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_18 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_18 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_18 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_18 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_18 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_18 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_18 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_18 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_18 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_18 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_18 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_18 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_18 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_18 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_18 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_18 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_18 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_18 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_18 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_18 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_18 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_18 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_18 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_18 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_18 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_18 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_18 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_18 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_18 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_18 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_18 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_18 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_18 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_18 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_18 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_18 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_18 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_18 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_18 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_18 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_18 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_18 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_18 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_18 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_18 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_18 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317011 S2P_Detail_Ucell1__19: 8 SBMU
 SG_ CSC_U_No_19 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_19 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_19 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_19 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_19 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_19 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_19 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_19 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_19 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_19 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_19 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_19 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_19 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_19 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_19 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_19 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_19 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_19 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_19 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_19 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_19 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_19 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_19 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_19 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_19 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_19 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_19 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_19 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_19 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_19 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_19 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_19 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_19 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_19 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_19 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_19 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_19 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_19 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_19 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_19 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_19 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_19 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_19 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_19 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_19 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_19 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_19 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_19 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_19 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_19 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_19 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_19 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_19 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_19 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_19 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_19 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_19 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_19 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_19 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317012 S2P_Detail_Ucell1__20: 8 SBMU
 SG_ CSC_U_No_20 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_20 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_20 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_20 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_20 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_20 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_20 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_20 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_20 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_20 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_20 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_20 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_20 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_20 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_20 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_20 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_20 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_20 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_20 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_20 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_20 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_20 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_20 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_20 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_20 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_20 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_20 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_20 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_20 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_20 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_20 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_20 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_20 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_20 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_20 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_20 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_20 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_20 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_20 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_20 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_20 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_20 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_20 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_20 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_20 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_20 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_20 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_20 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_20 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_20 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_20 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_20 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_20 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_20 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_20 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_20 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_20 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_20 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_20 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317013 S2P_Detail_Ucell1__21: 8 SBMU
 SG_ CSC_U_No_21 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_21 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_21 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_21 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_21 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_21 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_21 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_21 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_21 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_21 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_21 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_21 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_21 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_21 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_21 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_21 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_21 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_21 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_21 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_21 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_21 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_21 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_21 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_21 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_21 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_21 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_21 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_21 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_21 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_21 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_21 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_21 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_21 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_21 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_21 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_21 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_21 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_21 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_21 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_21 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_21 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_21 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_21 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_21 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_21 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_21 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_21 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_21 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_21 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_21 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_21 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_21 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_21 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_21 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_21 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_21 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_21 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_21 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_21 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317014 S2P_Detail_Ucell1__22: 8 SBMU
 SG_ CSC_U_No_22 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_22 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_22 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_22 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_22 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_22 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_22 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_22 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_22 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_22 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_22 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_22 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_22 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_22 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_22 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_22 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_22 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_22 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_22 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_22 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_22 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_22 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_22 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_22 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_22 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_22 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_22 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_22 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_22 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_22 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_22 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_22 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_22 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_22 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_22 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_22 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_22 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_22 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_22 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_22 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_22 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_22 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_22 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_22 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_22 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_22 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_22 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_22 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_22 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_22 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_22 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_22 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_22 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_22 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_22 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_22 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_22 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_22 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_22 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317015 S2P_Detail_Ucell1__23: 8 SBMU
 SG_ CSC_U_No_23 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_23 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_23 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_23 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_23 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_23 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_23 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_23 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_23 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_23 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_23 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_23 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_23 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_23 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_23 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_23 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_23 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_23 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_23 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_23 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_23 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_23 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_23 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_23 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_23 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_23 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_23 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_23 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_23 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_23 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_23 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_23 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_23 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_23 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_23 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_23 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_23 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_23 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_23 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_23 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_23 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_23 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_23 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_23 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_23 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_23 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_23 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_23 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_23 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_23 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_23 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_23 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_23 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_23 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_23 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_23 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_23 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_23 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_23 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317016 S2P_Detail_Ucell1__24: 8 SBMU
 SG_ CSC_U_No_24 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_24 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_24 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_24 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_24 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_24 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_24 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_24 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_24 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_24 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_24 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_24 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_24 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_24 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_24 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_24 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_24 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_24 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_24 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_24 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_24 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_24 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_24 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_24 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_24 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_24 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_24 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_24 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_24 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_24 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_24 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_24 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_24 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_24 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_24 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_24 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_24 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_24 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_24 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_24 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_24 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_24 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_24 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_24 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_24 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_24 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_24 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_24 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_24 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_24 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_24 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_24 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_24 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_24 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_24 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_24 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_24 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_24 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_24 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317017 S2P_Detail_Ucell1__25: 8 SBMU
 SG_ CSC_U_No_25 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_25 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_25 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_25 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_25 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_25 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_25 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_25 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_25 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_25 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_25 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_25 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_25 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_25 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_25 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_25 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_25 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_25 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_25 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_25 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_25 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_25 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_25 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_25 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_25 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_25 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_25 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_25 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_25 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_25 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_25 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_25 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_25 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_25 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_25 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_25 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_25 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_25 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_25 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_25 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_25 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_25 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_25 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_25 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_25 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_25 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_25 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_25 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_25 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_25 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_25 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_25 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_25 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_25 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_25 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_25 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_25 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_25 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_25 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317018 S2P_Detail_Ucell1__26: 8 SBMU
 SG_ CSC_U_No_26 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_26 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_26 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_26 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_26 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_26 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_26 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_26 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_26 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_26 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_26 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_26 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_26 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_26 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_26 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_26 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_26 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_26 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_26 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_26 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_26 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_26 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_26 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_26 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_26 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_26 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_26 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_26 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_26 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_26 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_26 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_26 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_26 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_26 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_26 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_26 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_26 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_26 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_26 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_26 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_26 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_26 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_26 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_26 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_26 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_26 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_26 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_26 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_26 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_26 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_26 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_26 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_26 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_26 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_26 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_26 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_26 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_26 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_26 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317019 S2P_Detail_Ucell1__27: 8 SBMU
 SG_ CSC_U_No_27 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_27 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_27 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_27 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_27 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_27 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_27 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_27 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_27 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_27 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_27 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_27 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_27 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_27 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_27 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_27 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_27 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_27 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_27 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_27 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_27 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_27 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_27 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_27 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_27 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_27 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_27 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_27 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_27 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_27 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_27 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_27 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_27 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_27 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_27 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_27 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_27 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_27 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_27 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_27 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_27 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_27 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_27 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_27 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_27 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_27 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_27 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_27 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_27 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_27 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_27 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_27 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_27 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_27 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_27 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_27 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_27 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_27 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_27 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

CM_ SG_ 2400317000 CSC_U_No_08 "CSC号";
CM_ SG_ 2400317000 CSC_Ucell_Frame_Index_08 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317000 CSC_Ucell_01_08 "01 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_02_08 "02 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_03_08 "03电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_04_08 "04  电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_05_08 "05 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_06_08 "06 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_07_08 "07  电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_08_08 "08 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_09_08 "09 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_10_08 "10 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_11_08 "11电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_12_08 "12 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_13_08 "13  电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_14_08 "14  电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_15_08 "15 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_16_08 "16 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_17_08 "17 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_18_08 "18 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_19_08 "19  电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_20_08 "20  电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_21_08 "21 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_22_08 "22 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_23_08 "23 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_24_08 "24 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_25_08 "25 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_26_08 "26 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_27_08 "27 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_28_08 "28 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_29_08 "29 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_30_08 "30 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_31_08 "31 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_32_08 "32 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_33_08 "33 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_34_08 "34 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_35_08 "35 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_36_08 "36 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_37_08 "37 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_38_08 "38 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_39_08 "39 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_40_08 "40 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_41_08 "41 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_42_08 "42 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_43_08 "43 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_44_08 "44 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_45_08 "45 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_46_08 "46 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_47_08 "47 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_48_08 "48 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_49_08 "49 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_50_08 "50 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_51_08 "51 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_52_08 "52 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_53_08 "53 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_54_08 "54 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_55_08 "55 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_56_08 "56 电池单体电压";
CM_ SG_ 2400317000 CSC_Ucell_57_08 "57 电池单体电压";
CM_ SG_ 2400317001 CSC_U_No_09 "CSC号";
CM_ SG_ 2400317001 CSC_Ucell_Frame_Index_09 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317001 CSC_Ucell_01_09 "01 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_02_09 "02 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_03_09 "03电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_04_09 "04  电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_05_09 "05 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_06_09 "06 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_07_09 "07  电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_08_09 "08 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_09_09 "09 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_10_09 "10 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_11_09 "11电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_12_09 "12 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_13_09 "13  电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_14_09 "14  电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_15_09 "15 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_16_09 "16 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_17_09 "17 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_18_09 "18 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_19_09 "19  电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_20_09 "20  电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_21_09 "21 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_22_09 "22 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_23_09 "23 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_24_09 "24 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_25_09 "25 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_26_09 "26 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_27_09 "27 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_28_09 "28 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_29_09 "29 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_30_09 "30 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_31_09 "31 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_32_09 "32 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_33_09 "33 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_34_09 "34 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_35_09 "35 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_36_09 "36 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_37_09 "37 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_38_09 "38 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_39_09 "39 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_40_09 "40 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_41_09 "41 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_42_09 "42 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_43_09 "43 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_44_09 "44 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_45_09 "45 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_46_09 "46 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_47_09 "47 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_48_09 "48 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_49_09 "49 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_50_09 "50 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_51_09 "51 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_52_09 "52 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_53_09 "53 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_54_09 "54 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_55_09 "55 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_56_09 "56 电池单体电压";
CM_ SG_ 2400317001 CSC_Ucell_57_09 "57 电池单体电压";
CM_ SG_ 2400317002 CSC_U_No_10 "CSC号";
CM_ SG_ 2400317002 CSC_Ucell_Frame_Index_10 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317002 CSC_Ucell_01_10 "01 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_02_10 "02 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_03_10 "03电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_04_10 "04  电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_05_10 "05 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_06_10 "06 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_07_10 "07  电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_08_10 "08 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_09_10 "09 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_10_10 "10 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_11_10 "11电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_12_10 "12 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_13_10 "13  电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_14_10 "14  电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_15_10 "15 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_16_10 "16 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_17_10 "17 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_18_10 "18 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_19_10 "19  电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_20_10 "20  电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_21_10 "21 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_22_10 "22 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_23_10 "23 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_24_10 "24 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_25_10 "25 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_26_10 "26 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_27_10 "27 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_28_10 "28 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_29_10 "29 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_30_10 "30 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_31_10 "31 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_32_10 "32 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_33_10 "33 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_34_10 "34 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_35_10 "35 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_36_10 "36 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_37_10 "37 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_38_10 "38 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_39_10 "39 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_40_10 "40 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_41_10 "41 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_42_10 "42 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_43_10 "43 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_44_10 "44 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_45_10 "45 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_46_10 "46 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_47_10 "47 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_48_10 "48 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_49_10 "49 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_50_10 "50 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_51_10 "51 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_52_10 "52 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_53_10 "53 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_54_10 "54 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_55_10 "55 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_56_10 "56 电池单体电压";
CM_ SG_ 2400317002 CSC_Ucell_57_10 "57 电池单体电压";
CM_ SG_ 2400317003 CSC_U_No_11 "CSC号";
CM_ SG_ 2400317003 CSC_Ucell_Frame_Index_11 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317003 CSC_Ucell_01_11 "01 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_02_11 "02 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_03_11 "03电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_04_11 "04  电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_05_11 "05 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_06_11 "06 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_07_11 "07  电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_08_11 "08 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_09_11 "09 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_10_11 "10 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_11_11 "11电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_12_11 "12 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_13_11 "13  电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_14_11 "14  电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_15_11 "15 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_16_11 "16 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_17_11 "17 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_18_11 "18 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_19_11 "19  电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_20_11 "20  电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_21_11 "21 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_22_11 "22 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_23_11 "23 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_24_11 "24 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_25_11 "25 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_26_11 "26 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_27_11 "27 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_28_11 "28 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_29_11 "29 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_30_11 "30 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_31_11 "31 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_32_11 "32 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_33_11 "33 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_34_11 "34 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_35_11 "35 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_36_11 "36 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_37_11 "37 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_38_11 "38 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_39_11 "39 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_40_11 "40 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_41_11 "41 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_42_11 "42 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_43_11 "43 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_44_11 "44 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_45_11 "45 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_46_11 "46 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_47_11 "47 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_48_11 "48 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_49_11 "49 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_50_11 "50 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_51_11 "51 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_52_11 "52 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_53_11 "53 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_54_11 "54 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_55_11 "55 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_56_11 "56 电池单体电压";
CM_ SG_ 2400317003 CSC_Ucell_57_11 "57 电池单体电压";
CM_ SG_ 2400317004 CSC_U_No_12 "CSC号";
CM_ SG_ 2400317004 CSC_Ucell_Frame_Index_12 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317004 CSC_Ucell_01_12 "01 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_02_12 "02 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_03_12 "03电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_04_12 "04  电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_05_12 "05 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_06_12 "06 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_07_12 "07  电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_08_12 "08 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_09_12 "09 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_10_12 "10 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_11_12 "11电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_12_12 "12 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_13_12 "13  电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_14_12 "14  电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_15_12 "15 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_16_12 "16 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_17_12 "17 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_18_12 "18 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_19_12 "19  电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_20_12 "20  电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_21_12 "21 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_22_12 "22 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_23_12 "23 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_24_12 "24 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_25_12 "25 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_26_12 "26 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_27_12 "27 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_28_12 "28 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_29_12 "29 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_30_12 "30 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_31_12 "31 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_32_12 "32 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_33_12 "33 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_34_12 "34 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_35_12 "35 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_36_12 "36 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_37_12 "37 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_38_12 "38 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_39_12 "39 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_40_12 "40 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_41_12 "41 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_42_12 "42 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_43_12 "43 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_44_12 "44 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_45_12 "45 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_46_12 "46 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_47_12 "47 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_48_12 "48 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_49_12 "49 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_50_12 "50 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_51_12 "51 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_52_12 "52 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_53_12 "53 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_54_12 "54 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_55_12 "55 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_56_12 "56 电池单体电压";
CM_ SG_ 2400317004 CSC_Ucell_57_12 "57 电池单体电压";
CM_ SG_ 2400317005 CSC_U_No_13 "CSC号";
CM_ SG_ 2400317005 CSC_Ucell_Frame_Index_13 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317005 CSC_Ucell_01_13 "01 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_02_13 "02 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_03_13 "03电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_04_13 "04  电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_05_13 "05 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_06_13 "06 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_07_13 "07  电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_08_13 "08 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_09_13 "09 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_10_13 "10 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_11_13 "11电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_12_13 "12 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_13_13 "13  电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_14_13 "14  电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_15_13 "15 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_16_13 "16 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_17_13 "17 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_18_13 "18 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_19_13 "19  电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_20_13 "20  电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_21_13 "21 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_22_13 "22 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_23_13 "23 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_24_13 "24 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_25_13 "25 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_26_13 "26 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_27_13 "27 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_28_13 "28 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_29_13 "29 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_30_13 "30 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_31_13 "31 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_32_13 "32 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_33_13 "33 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_34_13 "34 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_35_13 "35 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_36_13 "36 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_37_13 "37 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_38_13 "38 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_39_13 "39 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_40_13 "40 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_41_13 "41 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_42_13 "42 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_43_13 "43 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_44_13 "44 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_45_13 "45 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_46_13 "46 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_47_13 "47 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_48_13 "48 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_49_13 "49 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_50_13 "50 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_51_13 "51 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_52_13 "52 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_53_13 "53 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_54_13 "54 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_55_13 "55 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_56_13 "56 电池单体电压";
CM_ SG_ 2400317005 CSC_Ucell_57_13 "57 电池单体电压";
CM_ SG_ 2400317006 CSC_U_No_14 "CSC号";
CM_ SG_ 2400317006 CSC_Ucell_Frame_Index_14 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317006 CSC_Ucell_01_14 "01 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_02_14 "02 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_03_14 "03电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_04_14 "04  电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_05_14 "05 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_06_14 "06 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_07_14 "07  电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_08_14 "08 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_09_14 "09 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_10_14 "10 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_11_14 "11电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_12_14 "12 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_13_14 "13  电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_14_14 "14  电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_15_14 "15 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_16_14 "16 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_17_14 "17 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_18_14 "18 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_19_14 "19  电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_20_14 "20  电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_21_14 "21 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_22_14 "22 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_23_14 "23 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_24_14 "24 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_25_14 "25 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_26_14 "26 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_27_14 "27 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_28_14 "28 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_29_14 "29 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_30_14 "30 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_31_14 "31 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_32_14 "32 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_33_14 "33 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_34_14 "34 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_35_14 "35 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_36_14 "36 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_37_14 "37 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_38_14 "38 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_39_14 "39 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_40_14 "40 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_41_14 "41 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_42_14 "42 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_43_14 "43 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_44_14 "44 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_45_14 "45 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_46_14 "46 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_47_14 "47 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_48_14 "48 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_49_14 "49 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_50_14 "50 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_51_14 "51 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_52_14 "52 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_53_14 "53 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_54_14 "54 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_55_14 "55 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_56_14 "56 电池单体电压";
CM_ SG_ 2400317006 CSC_Ucell_57_14 "57 电池单体电压";
CM_ SG_ 2400317007 CSC_U_No_15 "CSC号";
CM_ SG_ 2400317007 CSC_Ucell_Frame_Index_15 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317007 CSC_Ucell_01_15 "01 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_02_15 "02 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_03_15 "03电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_04_15 "04  电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_05_15 "05 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_06_15 "06 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_07_15 "07  电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_08_15 "08 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_09_15 "09 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_10_15 "10 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_11_15 "11电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_12_15 "12 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_13_15 "13  电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_14_15 "14  电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_15_15 "15 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_16_15 "16 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_17_15 "17 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_18_15 "18 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_19_15 "19  电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_20_15 "20  电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_21_15 "21 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_22_15 "22 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_23_15 "23 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_24_15 "24 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_25_15 "25 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_26_15 "26 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_27_15 "27 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_28_15 "28 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_29_15 "29 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_30_15 "30 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_31_15 "31 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_32_15 "32 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_33_15 "33 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_34_15 "34 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_35_15 "35 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_36_15 "36 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_37_15 "37 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_38_15 "38 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_39_15 "39 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_40_15 "40 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_41_15 "41 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_42_15 "42 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_43_15 "43 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_44_15 "44 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_45_15 "45 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_46_15 "46 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_47_15 "47 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_48_15 "48 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_49_15 "49 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_50_15 "50 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_51_15 "51 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_52_15 "52 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_53_15 "53 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_54_15 "54 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_55_15 "55 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_56_15 "56 电池单体电压";
CM_ SG_ 2400317007 CSC_Ucell_57_15 "57 电池单体电压";
CM_ SG_ 2400317008 CSC_U_No_16 "CSC号";
CM_ SG_ 2400317008 CSC_Ucell_Frame_Index_16 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317008 CSC_Ucell_01_16 "01 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_02_16 "02 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_03_16 "03电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_04_16 "04  电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_05_16 "05 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_06_16 "06 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_07_16 "07  电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_08_16 "08 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_09_16 "09 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_10_16 "10 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_11_16 "11电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_12_16 "12 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_13_16 "13  电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_14_16 "14  电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_15_16 "15 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_16_16 "16 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_17_16 "17 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_18_16 "18 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_19_16 "19  电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_20_16 "20  电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_21_16 "21 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_22_16 "22 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_23_16 "23 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_24_16 "24 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_25_16 "25 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_26_16 "26 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_27_16 "27 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_28_16 "28 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_29_16 "29 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_30_16 "30 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_31_16 "31 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_32_16 "32 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_33_16 "33 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_34_16 "34 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_35_16 "35 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_36_16 "36 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_37_16 "37 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_38_16 "38 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_39_16 "39 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_40_16 "40 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_41_16 "41 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_42_16 "42 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_43_16 "43 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_44_16 "44 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_45_16 "45 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_46_16 "46 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_47_16 "47 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_48_16 "48 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_49_16 "49 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_50_16 "50 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_51_16 "51 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_52_16 "52 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_53_16 "53 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_54_16 "54 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_55_16 "55 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_56_16 "56 电池单体电压";
CM_ SG_ 2400317008 CSC_Ucell_57_16 "57 电池单体电压";
CM_ SG_ 2400317009 CSC_U_No_17 "CSC号";
CM_ SG_ 2400317009 CSC_Ucell_Frame_Index_17 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317009 CSC_Ucell_01_17 "01 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_02_17 "02 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_03_17 "03电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_04_17 "04  电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_05_17 "05 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_06_17 "06 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_07_17 "07  电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_08_17 "08 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_09_17 "09 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_10_17 "10 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_11_17 "11电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_12_17 "12 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_13_17 "13  电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_14_17 "14  电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_15_17 "15 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_16_17 "16 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_17_17 "17 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_18_17 "18 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_19_17 "19  电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_20_17 "20  电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_21_17 "21 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_22_17 "22 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_23_17 "23 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_24_17 "24 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_25_17 "25 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_26_17 "26 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_27_17 "27 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_28_17 "28 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_29_17 "29 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_30_17 "30 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_31_17 "31 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_32_17 "32 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_33_17 "33 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_34_17 "34 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_35_17 "35 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_36_17 "36 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_37_17 "37 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_38_17 "38 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_39_17 "39 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_40_17 "40 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_41_17 "41 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_42_17 "42 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_43_17 "43 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_44_17 "44 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_45_17 "45 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_46_17 "46 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_47_17 "47 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_48_17 "48 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_49_17 "49 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_50_17 "50 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_51_17 "51 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_52_17 "52 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_53_17 "53 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_54_17 "54 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_55_17 "55 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_56_17 "56 电池单体电压";
CM_ SG_ 2400317009 CSC_Ucell_57_17 "57 电池单体电压";
CM_ SG_ 2400317010 CSC_U_No_18 "CSC号";
CM_ SG_ 2400317010 CSC_Ucell_Frame_Index_18 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317010 CSC_Ucell_01_18 "01 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_02_18 "02 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_03_18 "03电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_04_18 "04  电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_05_18 "05 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_06_18 "06 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_07_18 "07  电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_08_18 "08 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_09_18 "09 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_10_18 "10 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_11_18 "11电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_12_18 "12 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_13_18 "13  电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_14_18 "14  电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_15_18 "15 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_16_18 "16 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_17_18 "17 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_18_18 "18 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_19_18 "19  电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_20_18 "20  电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_21_18 "21 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_22_18 "22 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_23_18 "23 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_24_18 "24 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_25_18 "25 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_26_18 "26 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_27_18 "27 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_28_18 "28 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_29_18 "29 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_30_18 "30 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_31_18 "31 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_32_18 "32 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_33_18 "33 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_34_18 "34 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_35_18 "35 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_36_18 "36 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_37_18 "37 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_38_18 "38 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_39_18 "39 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_40_18 "40 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_41_18 "41 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_42_18 "42 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_43_18 "43 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_44_18 "44 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_45_18 "45 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_46_18 "46 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_47_18 "47 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_48_18 "48 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_49_18 "49 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_50_18 "50 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_51_18 "51 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_52_18 "52 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_53_18 "53 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_54_18 "54 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_55_18 "55 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_56_18 "56 电池单体电压";
CM_ SG_ 2400317010 CSC_Ucell_57_18 "57 电池单体电压";
CM_ SG_ 2400317011 CSC_U_No_19 "CSC号";
CM_ SG_ 2400317011 CSC_Ucell_Frame_Index_19 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317011 CSC_Ucell_01_19 "01 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_02_19 "02 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_03_19 "03电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_04_19 "04  电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_05_19 "05 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_06_19 "06 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_07_19 "07  电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_08_19 "08 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_09_19 "09 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_10_19 "10 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_11_19 "11电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_12_19 "12 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_13_19 "13  电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_14_19 "14  电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_15_19 "15 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_16_19 "16 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_17_19 "17 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_18_19 "18 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_19_19 "19  电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_20_19 "20  电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_21_19 "21 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_22_19 "22 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_23_19 "23 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_24_19 "24 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_25_19 "25 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_26_19 "26 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_27_19 "27 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_28_19 "28 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_29_19 "29 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_30_19 "30 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_31_19 "31 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_32_19 "32 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_33_19 "33 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_34_19 "34 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_35_19 "35 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_36_19 "36 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_37_19 "37 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_38_19 "38 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_39_19 "39 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_40_19 "40 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_41_19 "41 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_42_19 "42 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_43_19 "43 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_44_19 "44 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_45_19 "45 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_46_19 "46 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_47_19 "47 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_48_19 "48 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_49_19 "49 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_50_19 "50 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_51_19 "51 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_52_19 "52 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_53_19 "53 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_54_19 "54 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_55_19 "55 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_56_19 "56 电池单体电压";
CM_ SG_ 2400317011 CSC_Ucell_57_19 "57 电池单体电压";
CM_ SG_ 2400317012 CSC_U_No_20 "CSC号";
CM_ SG_ 2400317012 CSC_Ucell_Frame_Index_20 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317012 CSC_Ucell_01_20 "01 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_02_20 "02 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_03_20 "03电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_04_20 "04  电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_05_20 "05 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_06_20 "06 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_07_20 "07  电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_08_20 "08 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_09_20 "09 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_10_20 "10 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_11_20 "11电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_12_20 "12 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_13_20 "13  电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_14_20 "14  电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_15_20 "15 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_16_20 "16 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_17_20 "17 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_18_20 "18 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_19_20 "19  电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_20_20 "20  电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_21_20 "21 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_22_20 "22 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_23_20 "23 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_24_20 "24 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_25_20 "25 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_26_20 "26 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_27_20 "27 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_28_20 "28 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_29_20 "29 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_30_20 "30 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_31_20 "31 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_32_20 "32 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_33_20 "33 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_34_20 "34 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_35_20 "35 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_36_20 "36 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_37_20 "37 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_38_20 "38 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_39_20 "39 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_40_20 "40 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_41_20 "41 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_42_20 "42 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_43_20 "43 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_44_20 "44 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_45_20 "45 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_46_20 "46 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_47_20 "47 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_48_20 "48 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_49_20 "49 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_50_20 "50 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_51_20 "51 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_52_20 "52 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_53_20 "53 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_54_20 "54 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_55_20 "55 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_56_20 "56 电池单体电压";
CM_ SG_ 2400317012 CSC_Ucell_57_20 "57 电池单体电压";
CM_ SG_ 2400317013 CSC_U_No_21 "CSC号";
CM_ SG_ 2400317013 CSC_Ucell_Frame_Index_21 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317013 CSC_Ucell_01_21 "01 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_02_21 "02 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_03_21 "03电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_04_21 "04  电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_05_21 "05 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_06_21 "06 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_07_21 "07  电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_08_21 "08 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_09_21 "09 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_10_21 "10 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_11_21 "11电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_12_21 "12 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_13_21 "13  电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_14_21 "14  电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_15_21 "15 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_16_21 "16 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_17_21 "17 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_18_21 "18 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_19_21 "19  电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_20_21 "20  电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_21_21 "21 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_22_21 "22 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_23_21 "23 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_24_21 "24 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_25_21 "25 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_26_21 "26 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_27_21 "27 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_28_21 "28 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_29_21 "29 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_30_21 "30 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_31_21 "31 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_32_21 "32 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_33_21 "33 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_34_21 "34 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_35_21 "35 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_36_21 "36 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_37_21 "37 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_38_21 "38 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_39_21 "39 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_40_21 "40 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_41_21 "41 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_42_21 "42 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_43_21 "43 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_44_21 "44 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_45_21 "45 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_46_21 "46 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_47_21 "47 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_48_21 "48 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_49_21 "49 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_50_21 "50 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_51_21 "51 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_52_21 "52 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_53_21 "53 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_54_21 "54 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_55_21 "55 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_56_21 "56 电池单体电压";
CM_ SG_ 2400317013 CSC_Ucell_57_21 "57 电池单体电压";
CM_ SG_ 2400317014 CSC_U_No_22 "CSC号";
CM_ SG_ 2400317014 CSC_Ucell_Frame_Index_22 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317014 CSC_Ucell_01_22 "01 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_02_22 "02 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_03_22 "03电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_04_22 "04  电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_05_22 "05 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_06_22 "06 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_07_22 "07  电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_08_22 "08 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_09_22 "09 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_10_22 "10 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_11_22 "11电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_12_22 "12 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_13_22 "13  电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_14_22 "14  电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_15_22 "15 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_16_22 "16 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_17_22 "17 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_18_22 "18 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_19_22 "19  电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_20_22 "20  电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_21_22 "21 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_22_22 "22 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_23_22 "23 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_24_22 "24 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_25_22 "25 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_26_22 "26 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_27_22 "27 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_28_22 "28 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_29_22 "29 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_30_22 "30 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_31_22 "31 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_32_22 "32 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_33_22 "33 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_34_22 "34 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_35_22 "35 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_36_22 "36 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_37_22 "37 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_38_22 "38 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_39_22 "39 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_40_22 "40 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_41_22 "41 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_42_22 "42 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_43_22 "43 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_44_22 "44 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_45_22 "45 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_46_22 "46 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_47_22 "47 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_48_22 "48 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_49_22 "49 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_50_22 "50 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_51_22 "51 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_52_22 "52 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_53_22 "53 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_54_22 "54 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_55_22 "55 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_56_22 "56 电池单体电压";
CM_ SG_ 2400317014 CSC_Ucell_57_22 "57 电池单体电压";
CM_ SG_ 2400317015 CSC_U_No_23 "CSC号";
CM_ SG_ 2400317015 CSC_Ucell_Frame_Index_23 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317015 CSC_Ucell_01_23 "01 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_02_23 "02 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_03_23 "03电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_04_23 "04  电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_05_23 "05 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_06_23 "06 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_07_23 "07  电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_08_23 "08 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_09_23 "09 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_10_23 "10 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_11_23 "11电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_12_23 "12 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_13_23 "13  电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_14_23 "14  电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_15_23 "15 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_16_23 "16 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_17_23 "17 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_18_23 "18 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_19_23 "19  电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_20_23 "20  电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_21_23 "21 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_22_23 "22 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_23_23 "23 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_24_23 "24 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_25_23 "25 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_26_23 "26 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_27_23 "27 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_28_23 "28 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_29_23 "29 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_30_23 "30 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_31_23 "31 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_32_23 "32 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_33_23 "33 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_34_23 "34 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_35_23 "35 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_36_23 "36 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_37_23 "37 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_38_23 "38 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_39_23 "39 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_40_23 "40 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_41_23 "41 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_42_23 "42 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_43_23 "43 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_44_23 "44 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_45_23 "45 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_46_23 "46 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_47_23 "47 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_48_23 "48 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_49_23 "49 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_50_23 "50 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_51_23 "51 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_52_23 "52 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_53_23 "53 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_54_23 "54 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_55_23 "55 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_56_23 "56 电池单体电压";
CM_ SG_ 2400317015 CSC_Ucell_57_23 "57 电池单体电压";
CM_ SG_ 2400317016 CSC_U_No_24 "CSC号";
CM_ SG_ 2400317016 CSC_Ucell_Frame_Index_24 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317016 CSC_Ucell_01_24 "01 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_02_24 "02 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_03_24 "03电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_04_24 "04  电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_05_24 "05 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_06_24 "06 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_07_24 "07  电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_08_24 "08 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_09_24 "09 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_10_24 "10 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_11_24 "11电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_12_24 "12 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_13_24 "13  电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_14_24 "14  电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_15_24 "15 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_16_24 "16 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_17_24 "17 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_18_24 "18 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_19_24 "19  电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_20_24 "20  电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_21_24 "21 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_22_24 "22 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_23_24 "23 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_24_24 "24 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_25_24 "25 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_26_24 "26 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_27_24 "27 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_28_24 "28 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_29_24 "29 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_30_24 "30 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_31_24 "31 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_32_24 "32 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_33_24 "33 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_34_24 "34 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_35_24 "35 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_36_24 "36 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_37_24 "37 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_38_24 "38 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_39_24 "39 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_40_24 "40 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_41_24 "41 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_42_24 "42 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_43_24 "43 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_44_24 "44 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_45_24 "45 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_46_24 "46 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_47_24 "47 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_48_24 "48 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_49_24 "49 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_50_24 "50 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_51_24 "51 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_52_24 "52 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_53_24 "53 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_54_24 "54 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_55_24 "55 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_56_24 "56 电池单体电压";
CM_ SG_ 2400317016 CSC_Ucell_57_24 "57 电池单体电压";
CM_ SG_ 2400317017 CSC_U_No_25 "CSC号";
CM_ SG_ 2400317017 CSC_Ucell_Frame_Index_25 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317017 CSC_Ucell_01_25 "01 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_02_25 "02 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_03_25 "03电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_04_25 "04  电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_05_25 "05 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_06_25 "06 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_07_25 "07  电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_08_25 "08 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_09_25 "09 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_10_25 "10 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_11_25 "11电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_12_25 "12 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_13_25 "13  电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_14_25 "14  电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_15_25 "15 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_16_25 "16 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_17_25 "17 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_18_25 "18 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_19_25 "19  电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_20_25 "20  电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_21_25 "21 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_22_25 "22 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_23_25 "23 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_24_25 "24 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_25_25 "25 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_26_25 "26 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_27_25 "27 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_28_25 "28 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_29_25 "29 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_30_25 "30 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_31_25 "31 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_32_25 "32 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_33_25 "33 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_34_25 "34 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_35_25 "35 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_36_25 "36 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_37_25 "37 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_38_25 "38 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_39_25 "39 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_40_25 "40 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_41_25 "41 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_42_25 "42 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_43_25 "43 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_44_25 "44 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_45_25 "45 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_46_25 "46 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_47_25 "47 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_48_25 "48 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_49_25 "49 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_50_25 "50 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_51_25 "51 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_52_25 "52 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_53_25 "53 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_54_25 "54 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_55_25 "55 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_56_25 "56 电池单体电压";
CM_ SG_ 2400317017 CSC_Ucell_57_25 "57 电池单体电压";
CM_ SG_ 2400317018 CSC_U_No_26 "CSC号";
CM_ SG_ 2400317018 CSC_Ucell_Frame_Index_26 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317018 CSC_Ucell_01_26 "01 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_02_26 "02 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_03_26 "03电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_04_26 "04  电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_05_26 "05 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_06_26 "06 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_07_26 "07  电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_08_26 "08 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_09_26 "09 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_10_26 "10 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_11_26 "11电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_12_26 "12 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_13_26 "13  电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_14_26 "14  电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_15_26 "15 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_16_26 "16 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_17_26 "17 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_18_26 "18 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_19_26 "19  电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_20_26 "20  电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_21_26 "21 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_22_26 "22 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_23_26 "23 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_24_26 "24 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_25_26 "25 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_26_26 "26 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_27_26 "27 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_28_26 "28 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_29_26 "29 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_30_26 "30 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_31_26 "31 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_32_26 "32 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_33_26 "33 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_34_26 "34 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_35_26 "35 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_36_26 "36 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_37_26 "37 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_38_26 "38 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_39_26 "39 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_40_26 "40 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_41_26 "41 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_42_26 "42 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_43_26 "43 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_44_26 "44 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_45_26 "45 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_46_26 "46 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_47_26 "47 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_48_26 "48 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_49_26 "49 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_50_26 "50 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_51_26 "51 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_52_26 "52 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_53_26 "53 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_54_26 "54 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_55_26 "55 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_56_26 "56 电池单体电压";
CM_ SG_ 2400317018 CSC_Ucell_57_26 "57 电池单体电压";
CM_ SG_ 2400317019 CSC_U_No_27 "CSC号";
CM_ SG_ 2400317019 CSC_Ucell_Frame_Index_27 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317019 CSC_Ucell_01_27 "01 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_02_27 "02 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_03_27 "03电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_04_27 "04  电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_05_27 "05 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_06_27 "06 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_07_27 "07  电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_08_27 "08 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_09_27 "09 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_10_27 "10 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_11_27 "11电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_12_27 "12 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_13_27 "13  电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_14_27 "14  电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_15_27 "15 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_16_27 "16 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_17_27 "17 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_18_27 "18 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_19_27 "19  电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_20_27 "20  电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_21_27 "21 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_22_27 "22 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_23_27 "23 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_24_27 "24 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_25_27 "25 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_26_27 "26 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_27_27 "27 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_28_27 "28 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_29_27 "29 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_30_27 "30 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_31_27 "31 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_32_27 "32 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_33_27 "33 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_34_27 "34 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_35_27 "35 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_36_27 "36 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_37_27 "37 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_38_27 "38 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_39_27 "39 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_40_27 "40 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_41_27 "41 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_42_27 "42 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_43_27 "43 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_44_27 "44 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_45_27 "45 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_46_27 "46 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_47_27 "47 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_48_27 "48 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_49_27 "49 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_50_27 "50 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_51_27 "51 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_52_27 "52 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_53_27 "53 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_54_27 "54 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_55_27 "55 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_56_27 "56 电池单体电压";
CM_ SG_ 2400317019 CSC_Ucell_57_27 "57 电池单体电压";
VAL_ 2400317000 CSC_U_No_08 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317000 CSC_Ucell_01_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_02_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_03_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_04_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_05_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_06_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_07_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_08_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_09_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_10_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_11_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_12_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_13_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_14_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_15_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_16_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_17_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_18_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_19_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_20_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_21_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_22_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_23_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_24_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_25_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_26_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_27_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_28_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_29_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_30_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_31_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_32_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_33_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_34_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_35_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_36_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_37_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_38_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_39_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_40_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_41_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_42_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_43_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_44_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_45_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_46_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_47_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_48_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_49_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_50_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_51_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_52_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_53_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_54_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_55_08 65535 "Invalid" ;
VAL_ 2400317000 CSC_Ucell_56_08 65535 "Invalid" ;
VAL_ 2400317001 CSC_U_No_09 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317001 CSC_Ucell_01_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_02_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_03_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_04_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_05_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_06_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_07_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_08_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_09_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_10_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_11_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_12_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_13_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_14_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_15_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_16_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_17_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_18_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_19_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_20_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_21_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_22_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_23_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_24_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_25_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_26_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_27_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_28_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_29_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_30_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_31_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_32_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_33_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_34_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_35_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_36_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_37_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_38_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_39_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_40_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_41_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_42_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_43_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_44_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_45_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_46_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_47_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_48_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_49_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_50_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_51_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_52_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_53_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_54_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_55_09 65535 "Invalid" ;
VAL_ 2400317001 CSC_Ucell_56_09 65535 "Invalid" ;
VAL_ 2400317002 CSC_U_No_10 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317002 CSC_Ucell_01_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_02_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_03_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_04_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_05_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_06_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_07_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_08_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_09_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_10_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_11_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_12_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_13_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_14_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_15_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_16_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_17_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_18_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_19_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_20_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_21_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_22_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_23_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_24_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_25_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_26_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_27_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_28_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_29_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_30_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_31_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_32_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_33_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_34_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_35_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_36_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_37_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_38_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_39_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_40_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_41_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_42_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_43_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_44_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_45_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_46_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_47_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_48_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_49_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_50_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_51_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_52_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_53_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_54_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_55_10 65535 "Invalid" ;
VAL_ 2400317002 CSC_Ucell_56_10 65535 "Invalid" ;
VAL_ 2400317003 CSC_U_No_11 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317003 CSC_Ucell_01_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_02_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_03_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_04_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_05_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_06_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_07_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_08_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_09_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_10_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_11_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_12_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_13_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_14_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_15_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_16_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_17_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_18_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_19_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_20_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_21_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_22_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_23_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_24_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_25_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_26_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_27_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_28_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_29_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_30_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_31_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_32_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_33_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_34_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_35_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_36_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_37_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_38_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_39_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_40_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_41_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_42_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_43_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_44_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_45_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_46_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_47_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_48_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_49_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_50_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_51_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_52_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_53_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_54_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_55_11 65535 "Invalid" ;
VAL_ 2400317003 CSC_Ucell_56_11 65535 "Invalid" ;
VAL_ 2400317004 CSC_U_No_12 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317004 CSC_Ucell_01_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_02_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_03_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_04_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_05_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_06_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_07_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_08_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_09_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_10_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_11_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_12_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_13_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_14_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_15_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_16_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_17_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_18_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_19_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_20_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_21_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_22_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_23_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_24_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_25_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_26_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_27_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_28_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_29_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_30_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_31_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_32_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_33_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_34_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_35_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_36_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_37_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_38_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_39_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_40_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_41_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_42_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_43_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_44_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_45_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_46_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_47_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_48_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_49_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_50_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_51_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_52_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_53_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_54_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_55_12 65535 "Invalid" ;
VAL_ 2400317004 CSC_Ucell_56_12 65535 "Invalid" ;
VAL_ 2400317005 CSC_U_No_13 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317005 CSC_Ucell_01_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_02_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_03_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_04_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_05_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_06_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_07_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_08_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_09_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_10_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_11_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_12_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_13_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_14_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_15_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_16_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_17_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_18_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_19_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_20_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_21_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_22_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_23_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_24_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_25_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_26_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_27_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_28_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_29_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_30_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_31_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_32_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_33_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_34_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_35_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_36_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_37_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_38_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_39_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_40_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_41_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_42_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_43_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_44_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_45_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_46_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_47_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_48_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_49_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_50_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_51_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_52_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_53_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_54_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_55_13 65535 "Invalid" ;
VAL_ 2400317005 CSC_Ucell_56_13 65535 "Invalid" ;
VAL_ 2400317006 CSC_U_No_14 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317006 CSC_Ucell_01_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_02_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_03_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_04_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_05_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_06_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_07_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_08_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_09_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_10_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_11_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_12_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_13_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_14_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_15_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_16_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_17_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_18_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_19_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_20_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_21_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_22_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_23_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_24_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_25_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_26_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_27_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_28_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_29_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_30_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_31_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_32_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_33_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_34_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_35_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_36_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_37_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_38_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_39_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_40_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_41_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_42_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_43_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_44_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_45_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_46_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_47_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_48_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_49_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_50_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_51_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_52_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_53_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_54_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_55_14 65535 "Invalid" ;
VAL_ 2400317006 CSC_Ucell_56_14 65535 "Invalid" ;
VAL_ 2400317007 CSC_U_No_15 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317007 CSC_Ucell_01_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_02_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_03_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_04_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_05_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_06_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_07_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_08_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_09_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_10_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_11_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_12_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_13_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_14_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_15_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_16_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_17_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_18_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_19_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_20_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_21_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_22_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_23_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_24_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_25_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_26_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_27_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_28_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_29_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_30_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_31_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_32_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_33_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_34_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_35_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_36_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_37_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_38_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_39_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_40_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_41_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_42_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_43_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_44_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_45_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_46_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_47_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_48_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_49_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_50_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_51_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_52_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_53_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_54_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_55_15 65535 "Invalid" ;
VAL_ 2400317007 CSC_Ucell_56_15 65535 "Invalid" ;
VAL_ 2400317008 CSC_U_No_16 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317008 CSC_Ucell_01_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_02_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_03_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_04_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_05_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_06_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_07_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_08_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_09_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_10_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_11_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_12_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_13_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_14_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_15_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_16_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_17_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_18_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_19_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_20_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_21_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_22_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_23_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_24_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_25_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_26_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_27_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_28_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_29_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_30_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_31_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_32_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_33_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_34_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_35_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_36_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_37_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_38_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_39_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_40_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_41_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_42_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_43_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_44_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_45_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_46_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_47_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_48_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_49_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_50_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_51_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_52_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_53_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_54_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_55_16 65535 "Invalid" ;
VAL_ 2400317008 CSC_Ucell_56_16 65535 "Invalid" ;
VAL_ 2400317009 CSC_U_No_17 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317009 CSC_Ucell_01_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_02_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_03_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_04_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_05_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_06_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_07_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_08_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_09_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_10_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_11_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_12_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_13_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_14_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_15_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_16_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_17_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_18_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_19_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_20_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_21_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_22_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_23_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_24_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_25_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_26_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_27_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_28_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_29_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_30_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_31_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_32_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_33_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_34_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_35_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_36_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_37_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_38_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_39_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_40_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_41_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_42_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_43_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_44_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_45_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_46_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_47_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_48_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_49_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_50_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_51_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_52_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_53_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_54_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_55_17 65535 "Invalid" ;
VAL_ 2400317009 CSC_Ucell_56_17 65535 "Invalid" ;
VAL_ 2400317010 CSC_U_No_18 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317010 CSC_Ucell_01_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_02_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_03_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_04_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_05_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_06_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_07_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_08_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_09_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_10_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_11_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_12_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_13_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_14_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_15_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_16_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_17_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_18_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_19_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_20_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_21_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_22_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_23_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_24_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_25_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_26_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_27_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_28_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_29_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_30_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_31_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_32_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_33_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_34_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_35_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_36_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_37_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_38_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_39_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_40_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_41_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_42_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_43_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_44_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_45_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_46_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_47_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_48_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_49_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_50_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_51_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_52_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_53_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_54_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_55_18 65535 "Invalid" ;
VAL_ 2400317010 CSC_Ucell_56_18 65535 "Invalid" ;
VAL_ 2400317011 CSC_U_No_19 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317011 CSC_Ucell_01_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_02_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_03_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_04_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_05_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_06_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_07_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_08_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_09_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_10_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_11_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_12_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_13_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_14_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_15_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_16_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_17_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_18_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_19_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_20_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_21_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_22_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_23_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_24_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_25_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_26_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_27_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_28_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_29_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_30_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_31_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_32_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_33_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_34_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_35_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_36_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_37_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_38_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_39_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_40_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_41_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_42_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_43_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_44_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_45_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_46_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_47_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_48_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_49_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_50_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_51_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_52_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_53_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_54_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_55_19 65535 "Invalid" ;
VAL_ 2400317011 CSC_Ucell_56_19 65535 "Invalid" ;
VAL_ 2400317012 CSC_U_No_20 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317012 CSC_Ucell_01_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_02_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_03_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_04_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_05_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_06_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_07_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_08_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_09_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_10_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_11_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_12_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_13_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_14_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_15_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_16_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_17_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_18_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_19_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_20_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_21_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_22_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_23_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_24_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_25_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_26_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_27_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_28_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_29_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_30_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_31_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_32_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_33_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_34_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_35_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_36_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_37_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_38_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_39_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_40_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_41_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_42_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_43_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_44_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_45_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_46_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_47_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_48_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_49_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_50_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_51_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_52_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_53_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_54_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_55_20 65535 "Invalid" ;
VAL_ 2400317012 CSC_Ucell_56_20 65535 "Invalid" ;
VAL_ 2400317013 CSC_U_No_21 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317013 CSC_Ucell_01_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_02_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_03_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_04_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_05_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_06_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_07_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_08_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_09_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_10_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_11_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_12_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_13_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_14_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_15_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_16_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_17_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_18_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_19_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_20_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_21_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_22_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_23_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_24_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_25_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_26_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_27_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_28_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_29_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_30_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_31_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_32_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_33_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_34_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_35_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_36_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_37_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_38_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_39_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_40_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_41_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_42_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_43_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_44_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_45_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_46_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_47_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_48_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_49_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_50_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_51_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_52_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_53_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_54_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_55_21 65535 "Invalid" ;
VAL_ 2400317013 CSC_Ucell_56_21 65535 "Invalid" ;
VAL_ 2400317014 CSC_U_No_22 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317014 CSC_Ucell_01_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_02_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_03_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_04_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_05_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_06_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_07_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_08_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_09_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_10_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_11_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_12_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_13_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_14_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_15_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_16_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_17_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_18_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_19_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_20_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_21_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_22_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_23_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_24_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_25_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_26_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_27_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_28_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_29_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_30_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_31_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_32_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_33_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_34_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_35_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_36_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_37_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_38_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_39_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_40_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_41_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_42_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_43_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_44_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_45_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_46_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_47_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_48_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_49_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_50_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_51_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_52_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_53_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_54_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_55_22 65535 "Invalid" ;
VAL_ 2400317014 CSC_Ucell_56_22 65535 "Invalid" ;
VAL_ 2400317015 CSC_U_No_23 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317015 CSC_Ucell_01_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_02_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_03_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_04_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_05_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_06_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_07_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_08_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_09_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_10_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_11_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_12_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_13_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_14_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_15_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_16_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_17_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_18_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_19_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_20_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_21_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_22_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_23_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_24_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_25_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_26_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_27_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_28_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_29_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_30_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_31_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_32_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_33_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_34_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_35_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_36_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_37_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_38_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_39_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_40_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_41_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_42_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_43_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_44_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_45_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_46_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_47_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_48_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_49_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_50_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_51_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_52_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_53_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_54_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_55_23 65535 "Invalid" ;
VAL_ 2400317015 CSC_Ucell_56_23 65535 "Invalid" ;
VAL_ 2400317016 CSC_U_No_24 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317016 CSC_Ucell_01_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_02_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_03_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_04_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_05_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_06_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_07_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_08_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_09_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_10_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_11_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_12_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_13_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_14_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_15_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_16_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_17_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_18_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_19_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_20_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_21_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_22_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_23_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_24_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_25_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_26_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_27_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_28_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_29_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_30_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_31_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_32_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_33_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_34_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_35_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_36_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_37_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_38_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_39_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_40_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_41_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_42_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_43_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_44_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_45_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_46_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_47_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_48_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_49_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_50_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_51_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_52_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_53_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_54_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_55_24 65535 "Invalid" ;
VAL_ 2400317016 CSC_Ucell_56_24 65535 "Invalid" ;
VAL_ 2400317017 CSC_U_No_25 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317017 CSC_Ucell_01_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_02_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_03_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_04_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_05_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_06_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_07_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_08_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_09_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_10_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_11_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_12_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_13_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_14_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_15_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_16_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_17_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_18_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_19_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_20_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_21_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_22_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_23_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_24_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_25_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_26_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_27_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_28_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_29_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_30_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_31_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_32_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_33_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_34_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_35_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_36_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_37_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_38_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_39_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_40_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_41_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_42_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_43_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_44_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_45_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_46_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_47_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_48_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_49_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_50_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_51_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_52_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_53_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_54_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_55_25 65535 "Invalid" ;
VAL_ 2400317017 CSC_Ucell_56_25 65535 "Invalid" ;
VAL_ 2400317018 CSC_U_No_26 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317018 CSC_Ucell_01_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_02_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_03_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_04_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_05_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_06_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_07_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_08_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_09_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_10_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_11_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_12_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_13_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_14_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_15_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_16_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_17_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_18_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_19_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_20_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_21_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_22_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_23_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_24_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_25_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_26_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_27_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_28_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_29_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_30_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_31_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_32_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_33_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_34_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_35_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_36_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_37_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_38_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_39_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_40_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_41_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_42_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_43_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_44_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_45_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_46_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_47_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_48_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_49_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_50_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_51_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_52_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_53_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_54_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_55_26 65535 "Invalid" ;
VAL_ 2400317018 CSC_Ucell_56_26 65535 "Invalid" ;
VAL_ 2400317019 CSC_U_No_27 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317019 CSC_Ucell_01_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_02_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_03_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_04_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_05_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_06_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_07_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_08_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_09_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_10_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_11_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_12_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_13_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_14_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_15_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_16_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_17_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_18_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_19_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_20_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_21_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_22_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_23_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_24_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_25_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_26_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_27_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_28_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_29_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_30_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_31_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_32_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_33_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_34_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_35_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_36_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_37_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_38_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_39_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_40_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_41_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_42_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_43_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_44_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_45_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_46_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_47_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_48_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_49_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_50_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_51_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_52_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_53_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_54_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_55_27 65535 "Invalid" ;
VAL_ 2400317019 CSC_Ucell_56_27 65535 "Invalid" ;
