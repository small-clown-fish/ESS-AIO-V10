VERSION ""

NS_ :

BS_:

BU_: MBMU PC SBMU IMM ETH DCDC LEMS

BO_ 2400317040 S2P_Detail_Ucell1__48: 8 SBMU
 SG_ CSC_U_No_48 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_48 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_48 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_48 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_48 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_48 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_48 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_48 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_48 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_48 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_48 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_48 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_48 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_48 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_48 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_48 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_48 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_48 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_48 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_48 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_48 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_48 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_48 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_48 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_48 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_48 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_48 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_48 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_48 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_48 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_48 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_48 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_48 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_48 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_48 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_48 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_48 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_48 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_48 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_48 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_48 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_48 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_48 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_48 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_48 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_48 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_48 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_48 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_48 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_48 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_48 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_48 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_48 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_48 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_48 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_48 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_48 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_48 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_48 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317041 S2P_Detail_Ucell1__49: 8 SBMU
 SG_ CSC_U_No_49 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_49 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_49 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_49 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_49 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_49 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_49 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_49 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_49 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_49 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_49 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_49 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_49 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_49 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_49 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_49 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_49 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_49 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_49 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_49 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_49 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_49 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_49 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_49 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_49 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_49 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_49 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_49 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_49 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_49 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_49 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_49 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_49 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_49 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_49 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_49 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_49 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_49 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_49 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_49 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_49 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_49 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_49 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_49 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_49 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_49 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_49 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_49 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_49 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_49 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_49 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_49 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_49 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_49 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_49 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_49 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_49 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_49 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_49 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317042 S2P_Detail_Ucell1__50: 8 SBMU
 SG_ CSC_U_No_50 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_50 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_50 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_50 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_50 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_50 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_50 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_50 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_50 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_50 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_50 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_50 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_50 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_50 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_50 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_50 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_50 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_50 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_50 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_50 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_50 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_50 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_50 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_50 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_50 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_50 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_50 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_50 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_50 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_50 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_50 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_50 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_50 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_50 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_50 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_50 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_50 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_50 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_50 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_50 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_50 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_50 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_50 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_50 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_50 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_50 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_50 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_50 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_50 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_50 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_50 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_50 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_50 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_50 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_50 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_50 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_50 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_50 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_50 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317043 S2P_Detail_Ucell1__51: 8 SBMU
 SG_ CSC_U_No_51 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_51 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_51 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_51 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_51 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_51 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_51 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_51 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_51 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_51 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_51 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_51 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_51 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_51 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_51 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_51 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_51 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_51 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_51 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_51 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_51 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_51 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_51 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_51 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_51 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_51 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_51 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_51 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_51 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_51 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_51 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_51 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_51 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_51 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_51 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_51 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_51 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_51 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_51 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_51 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_51 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_51 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_51 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_51 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_51 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_51 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_51 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_51 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_51 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_51 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_51 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_51 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_51 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_51 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_51 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_51 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_51 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_51 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_51 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317044 S2P_Detail_Ucell1__52: 8 SBMU
 SG_ CSC_U_No_52 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_52 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_52 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_52 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_52 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_52 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_52 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_52 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_52 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_52 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_52 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_52 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_52 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_52 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_52 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_52 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_52 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_52 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_52 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_52 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_52 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_52 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_52 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_52 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_52 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_52 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_52 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_52 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_52 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_52 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_52 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_52 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_52 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_52 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_52 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_52 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_52 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_52 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_52 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_52 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_52 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_52 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_52 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_52 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_52 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_52 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_52 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_52 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_52 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_52 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_52 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_52 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_52 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_52 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_52 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_52 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_52 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_52 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_52 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317045 S2P_Detail_Ucell1__53: 8 SBMU
 SG_ CSC_U_No_53 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_53 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_53 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_53 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_53 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_53 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_53 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_53 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_53 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_53 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_53 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_53 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_53 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_53 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_53 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_53 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_53 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_53 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_53 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_53 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_53 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_53 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_53 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_53 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_53 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_53 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_53 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_53 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_53 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_53 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_53 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_53 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_53 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_53 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_53 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_53 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_53 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_53 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_53 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_53 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_53 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_53 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_53 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_53 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_53 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_53 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_53 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_53 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_53 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_53 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_53 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_53 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_53 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_53 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_53 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_53 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_53 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_53 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_53 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317046 S2P_Detail_Ucell1__54: 8 SBMU
 SG_ CSC_U_No_54 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_54 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_54 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_54 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_54 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_54 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_54 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_54 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_54 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_54 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_54 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_54 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_54 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_54 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_54 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_54 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_54 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_54 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_54 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_54 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_54 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_54 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_54 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_54 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_54 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_54 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_54 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_54 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_54 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_54 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_54 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_54 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_54 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_54 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_54 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_54 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_54 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_54 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_54 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_54 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_54 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_54 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_54 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_54 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_54 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_54 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_54 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_54 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_54 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_54 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_54 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_54 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_54 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_54 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_54 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_54 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_54 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_54 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_54 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317047 S2P_Detail_Ucell1__55: 8 SBMU
 SG_ CSC_U_No_55 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_55 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_55 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_55 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_55 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_55 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_55 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_55 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_55 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_55 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_55 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_55 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_55 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_55 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_55 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_55 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_55 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_55 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_55 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_55 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_55 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_55 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_55 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_55 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_55 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_55 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_55 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_55 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_55 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_55 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_55 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_55 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_55 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_55 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_55 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_55 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_55 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_55 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_55 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_55 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_55 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_55 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_55 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_55 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_55 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_55 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_55 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_55 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_55 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_55 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_55 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_55 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_55 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_55 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_55 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_55 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_55 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_55 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_55 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317048 S2P_Detail_Ucell1__56: 8 SBMU
 SG_ CSC_U_No_56 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_56 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_56 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_56 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_56 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_56 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_56 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_56 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_56 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_56 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_56 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_56 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_56 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_56 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_56 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_56 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_56 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_56 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_56 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_56 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_56 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_56 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_56 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_56 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_56 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_56 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_56 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_56 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_56 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_56 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_56 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_56 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_56 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_56 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_56 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_56 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_56 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_56 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_56 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_56 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_56 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_56 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_56 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_56 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_56 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_56 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_56 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_56 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_56 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_56 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_56 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_56 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_56 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_56 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_56 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_56 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_56 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_56 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_56 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317049 S2P_Detail_Ucell1__57: 8 SBMU
 SG_ CSC_U_No_57 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_57 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_57 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_57 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_57 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_57 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_57 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_57 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_57 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_57 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_57 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_57 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_57 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_57 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_57 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_57 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_57 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_57 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_57 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_57 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_57 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_57 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_57 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_57 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_57 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_57 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_57 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_57 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_57 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_57 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_57 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_57 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_57 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_57 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_57 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_57 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_57 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_57 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_57 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_57 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_57 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_57 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_57 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_57 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_57 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_57 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_57 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_57 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_57 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_57 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_57 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_57 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_57 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_57 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_57 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_57 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_57 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_57 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_57 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317050 S2P_Detail_Ucell1__58: 8 SBMU
 SG_ CSC_U_No_58 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_58 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_58 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_58 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_58 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_58 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_58 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_58 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_58 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_58 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_58 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_58 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_58 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_58 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_58 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_58 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_58 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_58 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_58 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_58 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_58 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_58 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_58 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_58 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_58 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_58 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_58 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_58 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_58 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_58 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_58 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_58 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_58 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_58 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_58 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_58 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_58 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_58 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_58 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_58 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_58 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_58 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_58 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_58 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_58 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_58 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_58 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_58 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_58 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_58 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_58 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_58 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_58 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_58 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_58 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_58 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_58 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_58 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_58 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317051 S2P_Detail_Ucell1__59: 8 SBMU
 SG_ CSC_U_No_59 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_59 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_59 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_59 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_59 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_59 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_59 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_59 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_59 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_59 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_59 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_59 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_59 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_59 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_59 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_59 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_59 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_59 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_59 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_59 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_59 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_59 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_59 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_59 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_59 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_59 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_59 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_59 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_59 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_59 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_59 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_59 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_59 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_59 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_59 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_59 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_59 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_59 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_59 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_59 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_59 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_59 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_59 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_59 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_59 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_59 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_59 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_59 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_59 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_59 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_59 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_59 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_59 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_59 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_59 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_59 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_59 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_59 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_59 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317052 S2P_Detail_Ucell1__60: 8 SBMU
 SG_ CSC_U_No_60 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_60 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_60 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_60 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_60 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_60 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_60 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_60 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_60 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_60 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_60 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_60 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_60 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_60 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_60 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_60 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_60 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_60 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_60 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_60 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_60 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_60 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_60 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_60 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_60 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_60 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_60 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_60 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_60 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_60 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_60 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_60 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_60 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_60 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_60 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_60 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_60 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_60 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_60 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_60 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_60 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_60 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_60 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_60 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_60 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_60 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_60 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_60 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_60 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_60 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_60 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_60 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_60 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_60 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_60 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_60 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_60 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_60 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_60 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317053 S2P_Detail_Ucell1__61: 8 SBMU
 SG_ CSC_U_No_61 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_61 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_61 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_61 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_61 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_61 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_61 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_61 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_61 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_61 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_61 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_61 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_61 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_61 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_61 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_61 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_61 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_61 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_61 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_61 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_61 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_61 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_61 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_61 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_61 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_61 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_61 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_61 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_61 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_61 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_61 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_61 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_61 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_61 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_61 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_61 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_61 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_61 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_61 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_61 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_61 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_61 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_61 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_61 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_61 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_61 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_61 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_61 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_61 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_61 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_61 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_61 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_61 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_61 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_61 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_61 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_61 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_61 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_61 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317054 S2P_Detail_Ucell1__62: 8 SBMU
 SG_ CSC_U_No_62 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_62 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_62 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_62 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_62 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_62 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_62 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_62 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_62 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_62 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_62 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_62 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_62 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_62 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_62 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_62 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_62 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_62 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_62 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_62 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_62 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_62 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_62 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_62 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_62 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_62 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_62 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_62 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_62 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_62 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_62 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_62 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_62 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_62 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_62 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_62 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_62 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_62 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_62 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_62 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_62 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_62 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_62 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_62 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_62 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_62 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_62 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_62 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_62 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_62 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_62 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_62 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_62 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_62 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_62 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_62 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_62 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_62 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_62 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400317055 S2P_Detail_Ucell1__63: 8 SBMU
 SG_ CSC_U_No_63 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_Frame_Index_63 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Ucell_01_63 m0 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_02_63 m0 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_03_63 m0 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_04_63 m1 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_05_63 m1 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_06_63 m1 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_07_63 m2 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_08_63 m2 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_09_63 m2 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_10_63 m3 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_11_63 m3 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_12_63 m3 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_13_63 m4 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_14_63 m4 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_15_63 m4 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_16_63 m5 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_17_63 m5 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_18_63 m5 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_19_63 m6 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_20_63 m6 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_21_63 m6 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_22_63 m7 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_23_63 m7 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_24_63 m7 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_25_63 m8 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_26_63 m8 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_27_63 m8 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_28_63 m9 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_29_63 m9 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_30_63 m9 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_31_63 m10 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_32_63 m10 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_33_63 m10 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_34_63 m11 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_35_63 m11 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_36_63 m11 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_37_63 m12 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_38_63 m12 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_39_63 m12 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_40_63 m13 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_41_63 m13 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_42_63 m13 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_43_63 m14 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_44_63 m14 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_45_63 m14 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_46_63 m15 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_47_63 m15 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_48_63 m15 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_49_63 m16 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_50_63 m16 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_51_63 m16 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_52_63 m17 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_53_63 m17 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_54_63 m17 : 48|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_55_63 m18 : 16|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_56_63 m18 : 32|16@1+ (1,0) [0|65535] "mV"  PC
 SG_ CSC_Ucell_57_63 m18 : 48|16@1+ (1,0) [0|65535] ""  PC

BO_ 2400382529 S2P_Detail_Tcell1__01: 8 SBMU
 SG_ CSC_T_No_01 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_01 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_01 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_01 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_01 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_01 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_01 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_01 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_01 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_01 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_01 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_01 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_01 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_01 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_01 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_01 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_01 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_01 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_01 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_01 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_01 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_01 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_01 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_01 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_01 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_01 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_01 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_01 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_01 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_01 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_01 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_01 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_01 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_01 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_01 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_01 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_01 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_01 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_01 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_01 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_01 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_01 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_01 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_01 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_01 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_01 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_01 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_01 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_01 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_01 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_01 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_01 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_01 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_01 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_01 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_01 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_01 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_01 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_01 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_01 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_01 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_01 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_01 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_01 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_01 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_01 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_01 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_01 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_01 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_01 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_01 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_01 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_01 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_01 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382530 S2P_Detail_Tcell1__02: 8 SBMU
 SG_ CSC_T_No_02 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_02 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_02 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_02 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_02 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_02 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_02 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_02 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_02 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_02 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_02 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_02 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_02 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_02 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_02 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_02 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_02 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_02 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_02 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_02 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_02 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_02 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_02 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_02 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_02 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_02 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_02 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_02 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_02 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_02 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_02 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_02 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_02 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_02 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_02 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_02 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_02 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_02 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_02 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_02 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_02 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_02 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_02 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_02 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_02 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_02 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_02 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_02 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_02 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_02 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_02 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_02 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_02 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_02 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_02 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_02 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_02 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_02 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_02 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_02 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_02 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_02 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_02 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_02 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_02 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_02 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_02 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_02 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_02 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_02 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_02 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_02 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_02 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_02 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382531 S2P_Detail_Tcell1__03: 8 SBMU
 SG_ CSC_T_No_03 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_03 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_03 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_03 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_03 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_03 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_03 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_03 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_03 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_03 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_03 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_03 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_03 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_03 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_03 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_03 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_03 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_03 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_03 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_03 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_03 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_03 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_03 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_03 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_03 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_03 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_03 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_03 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_03 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_03 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_03 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_03 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_03 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_03 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_03 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_03 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_03 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_03 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_03 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_03 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_03 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_03 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_03 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_03 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_03 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_03 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_03 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_03 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_03 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_03 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_03 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_03 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_03 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_03 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_03 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_03 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_03 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_03 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_03 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_03 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_03 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_03 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_03 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_03 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_03 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_03 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_03 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_03 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_03 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_03 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_03 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_03 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_03 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_03 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

CM_ SG_ 2400317040 CSC_U_No_48 "CSC号";
CM_ SG_ 2400317040 CSC_Ucell_Frame_Index_48 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317040 CSC_Ucell_01_48 "01 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_02_48 "02 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_03_48 "03电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_04_48 "04  电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_05_48 "05 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_06_48 "06 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_07_48 "07  电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_08_48 "08 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_09_48 "09 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_10_48 "10 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_11_48 "11电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_12_48 "12 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_13_48 "13  电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_14_48 "14  电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_15_48 "15 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_16_48 "16 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_17_48 "17 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_18_48 "18 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_19_48 "19  电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_20_48 "20  电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_21_48 "21 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_22_48 "22 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_23_48 "23 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_24_48 "24 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_25_48 "25 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_26_48 "26 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_27_48 "27 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_28_48 "28 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_29_48 "29 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_30_48 "30 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_31_48 "31 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_32_48 "32 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_33_48 "33 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_34_48 "34 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_35_48 "35 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_36_48 "36 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_37_48 "37 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_38_48 "38 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_39_48 "39 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_40_48 "40 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_41_48 "41 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_42_48 "42 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_43_48 "43 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_44_48 "44 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_45_48 "45 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_46_48 "46 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_47_48 "47 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_48_48 "48 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_49_48 "49 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_50_48 "50 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_51_48 "51 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_52_48 "52 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_53_48 "53 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_54_48 "54 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_55_48 "55 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_56_48 "56 电池单体电压";
CM_ SG_ 2400317040 CSC_Ucell_57_48 "57 电池单体电压";
CM_ SG_ 2400317041 CSC_U_No_49 "CSC号";
CM_ SG_ 2400317041 CSC_Ucell_Frame_Index_49 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317041 CSC_Ucell_01_49 "01 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_02_49 "02 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_03_49 "03电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_04_49 "04  电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_05_49 "05 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_06_49 "06 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_07_49 "07  电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_08_49 "08 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_09_49 "09 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_10_49 "10 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_11_49 "11电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_12_49 "12 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_13_49 "13  电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_14_49 "14  电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_15_49 "15 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_16_49 "16 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_17_49 "17 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_18_49 "18 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_19_49 "19  电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_20_49 "20  电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_21_49 "21 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_22_49 "22 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_23_49 "23 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_24_49 "24 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_25_49 "25 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_26_49 "26 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_27_49 "27 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_28_49 "28 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_29_49 "29 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_30_49 "30 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_31_49 "31 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_32_49 "32 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_33_49 "33 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_34_49 "34 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_35_49 "35 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_36_49 "36 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_37_49 "37 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_38_49 "38 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_39_49 "39 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_40_49 "40 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_41_49 "41 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_42_49 "42 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_43_49 "43 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_44_49 "44 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_45_49 "45 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_46_49 "46 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_47_49 "47 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_48_49 "48 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_49_49 "49 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_50_49 "50 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_51_49 "51 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_52_49 "52 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_53_49 "53 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_54_49 "54 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_55_49 "55 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_56_49 "56 电池单体电压";
CM_ SG_ 2400317041 CSC_Ucell_57_49 "57 电池单体电压";
CM_ SG_ 2400317042 CSC_U_No_50 "CSC号";
CM_ SG_ 2400317042 CSC_Ucell_Frame_Index_50 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317042 CSC_Ucell_01_50 "01 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_02_50 "02 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_03_50 "03电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_04_50 "04  电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_05_50 "05 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_06_50 "06 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_07_50 "07  电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_08_50 "08 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_09_50 "09 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_10_50 "10 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_11_50 "11电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_12_50 "12 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_13_50 "13  电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_14_50 "14  电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_15_50 "15 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_16_50 "16 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_17_50 "17 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_18_50 "18 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_19_50 "19  电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_20_50 "20  电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_21_50 "21 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_22_50 "22 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_23_50 "23 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_24_50 "24 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_25_50 "25 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_26_50 "26 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_27_50 "27 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_28_50 "28 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_29_50 "29 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_30_50 "30 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_31_50 "31 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_32_50 "32 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_33_50 "33 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_34_50 "34 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_35_50 "35 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_36_50 "36 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_37_50 "37 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_38_50 "38 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_39_50 "39 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_40_50 "40 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_41_50 "41 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_42_50 "42 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_43_50 "43 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_44_50 "44 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_45_50 "45 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_46_50 "46 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_47_50 "47 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_48_50 "48 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_49_50 "49 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_50_50 "50 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_51_50 "51 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_52_50 "52 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_53_50 "53 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_54_50 "54 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_55_50 "55 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_56_50 "56 电池单体电压";
CM_ SG_ 2400317042 CSC_Ucell_57_50 "57 电池单体电压";
CM_ SG_ 2400317043 CSC_U_No_51 "CSC号";
CM_ SG_ 2400317043 CSC_Ucell_Frame_Index_51 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317043 CSC_Ucell_01_51 "01 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_02_51 "02 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_03_51 "03电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_04_51 "04  电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_05_51 "05 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_06_51 "06 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_07_51 "07  电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_08_51 "08 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_09_51 "09 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_10_51 "10 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_11_51 "11电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_12_51 "12 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_13_51 "13  电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_14_51 "14  电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_15_51 "15 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_16_51 "16 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_17_51 "17 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_18_51 "18 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_19_51 "19  电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_20_51 "20  电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_21_51 "21 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_22_51 "22 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_23_51 "23 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_24_51 "24 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_25_51 "25 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_26_51 "26 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_27_51 "27 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_28_51 "28 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_29_51 "29 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_30_51 "30 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_31_51 "31 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_32_51 "32 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_33_51 "33 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_34_51 "34 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_35_51 "35 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_36_51 "36 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_37_51 "37 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_38_51 "38 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_39_51 "39 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_40_51 "40 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_41_51 "41 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_42_51 "42 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_43_51 "43 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_44_51 "44 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_45_51 "45 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_46_51 "46 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_47_51 "47 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_48_51 "48 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_49_51 "49 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_50_51 "50 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_51_51 "51 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_52_51 "52 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_53_51 "53 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_54_51 "54 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_55_51 "55 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_56_51 "56 电池单体电压";
CM_ SG_ 2400317043 CSC_Ucell_57_51 "57 电池单体电压";
CM_ SG_ 2400317044 CSC_U_No_52 "CSC号";
CM_ SG_ 2400317044 CSC_Ucell_Frame_Index_52 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317044 CSC_Ucell_01_52 "01 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_02_52 "02 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_03_52 "03电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_04_52 "04  电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_05_52 "05 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_06_52 "06 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_07_52 "07  电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_08_52 "08 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_09_52 "09 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_10_52 "10 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_11_52 "11电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_12_52 "12 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_13_52 "13  电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_14_52 "14  电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_15_52 "15 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_16_52 "16 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_17_52 "17 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_18_52 "18 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_19_52 "19  电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_20_52 "20  电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_21_52 "21 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_22_52 "22 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_23_52 "23 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_24_52 "24 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_25_52 "25 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_26_52 "26 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_27_52 "27 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_28_52 "28 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_29_52 "29 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_30_52 "30 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_31_52 "31 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_32_52 "32 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_33_52 "33 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_34_52 "34 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_35_52 "35 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_36_52 "36 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_37_52 "37 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_38_52 "38 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_39_52 "39 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_40_52 "40 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_41_52 "41 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_42_52 "42 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_43_52 "43 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_44_52 "44 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_45_52 "45 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_46_52 "46 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_47_52 "47 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_48_52 "48 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_49_52 "49 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_50_52 "50 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_51_52 "51 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_52_52 "52 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_53_52 "53 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_54_52 "54 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_55_52 "55 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_56_52 "56 电池单体电压";
CM_ SG_ 2400317044 CSC_Ucell_57_52 "57 电池单体电压";
CM_ SG_ 2400317045 CSC_U_No_53 "CSC号";
CM_ SG_ 2400317045 CSC_Ucell_Frame_Index_53 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317045 CSC_Ucell_01_53 "01 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_02_53 "02 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_03_53 "03电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_04_53 "04  电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_05_53 "05 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_06_53 "06 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_07_53 "07  电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_08_53 "08 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_09_53 "09 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_10_53 "10 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_11_53 "11电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_12_53 "12 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_13_53 "13  电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_14_53 "14  电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_15_53 "15 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_16_53 "16 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_17_53 "17 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_18_53 "18 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_19_53 "19  电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_20_53 "20  电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_21_53 "21 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_22_53 "22 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_23_53 "23 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_24_53 "24 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_25_53 "25 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_26_53 "26 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_27_53 "27 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_28_53 "28 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_29_53 "29 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_30_53 "30 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_31_53 "31 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_32_53 "32 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_33_53 "33 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_34_53 "34 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_35_53 "35 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_36_53 "36 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_37_53 "37 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_38_53 "38 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_39_53 "39 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_40_53 "40 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_41_53 "41 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_42_53 "42 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_43_53 "43 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_44_53 "44 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_45_53 "45 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_46_53 "46 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_47_53 "47 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_48_53 "48 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_49_53 "49 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_50_53 "50 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_51_53 "51 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_52_53 "52 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_53_53 "53 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_54_53 "54 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_55_53 "55 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_56_53 "56 电池单体电压";
CM_ SG_ 2400317045 CSC_Ucell_57_53 "57 电池单体电压";
CM_ SG_ 2400317046 CSC_U_No_54 "CSC号";
CM_ SG_ 2400317046 CSC_Ucell_Frame_Index_54 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317046 CSC_Ucell_01_54 "01 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_02_54 "02 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_03_54 "03电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_04_54 "04  电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_05_54 "05 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_06_54 "06 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_07_54 "07  电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_08_54 "08 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_09_54 "09 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_10_54 "10 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_11_54 "11电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_12_54 "12 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_13_54 "13  电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_14_54 "14  电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_15_54 "15 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_16_54 "16 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_17_54 "17 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_18_54 "18 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_19_54 "19  电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_20_54 "20  电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_21_54 "21 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_22_54 "22 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_23_54 "23 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_24_54 "24 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_25_54 "25 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_26_54 "26 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_27_54 "27 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_28_54 "28 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_29_54 "29 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_30_54 "30 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_31_54 "31 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_32_54 "32 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_33_54 "33 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_34_54 "34 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_35_54 "35 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_36_54 "36 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_37_54 "37 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_38_54 "38 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_39_54 "39 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_40_54 "40 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_41_54 "41 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_42_54 "42 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_43_54 "43 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_44_54 "44 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_45_54 "45 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_46_54 "46 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_47_54 "47 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_48_54 "48 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_49_54 "49 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_50_54 "50 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_51_54 "51 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_52_54 "52 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_53_54 "53 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_54_54 "54 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_55_54 "55 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_56_54 "56 电池单体电压";
CM_ SG_ 2400317046 CSC_Ucell_57_54 "57 电池单体电压";
CM_ SG_ 2400317047 CSC_U_No_55 "CSC号";
CM_ SG_ 2400317047 CSC_Ucell_Frame_Index_55 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317047 CSC_Ucell_01_55 "01 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_02_55 "02 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_03_55 "03电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_04_55 "04  电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_05_55 "05 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_06_55 "06 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_07_55 "07  电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_08_55 "08 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_09_55 "09 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_10_55 "10 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_11_55 "11电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_12_55 "12 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_13_55 "13  电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_14_55 "14  电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_15_55 "15 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_16_55 "16 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_17_55 "17 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_18_55 "18 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_19_55 "19  电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_20_55 "20  电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_21_55 "21 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_22_55 "22 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_23_55 "23 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_24_55 "24 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_25_55 "25 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_26_55 "26 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_27_55 "27 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_28_55 "28 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_29_55 "29 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_30_55 "30 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_31_55 "31 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_32_55 "32 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_33_55 "33 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_34_55 "34 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_35_55 "35 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_36_55 "36 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_37_55 "37 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_38_55 "38 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_39_55 "39 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_40_55 "40 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_41_55 "41 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_42_55 "42 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_43_55 "43 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_44_55 "44 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_45_55 "45 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_46_55 "46 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_47_55 "47 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_48_55 "48 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_49_55 "49 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_50_55 "50 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_51_55 "51 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_52_55 "52 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_53_55 "53 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_54_55 "54 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_55_55 "55 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_56_55 "56 电池单体电压";
CM_ SG_ 2400317047 CSC_Ucell_57_55 "57 电池单体电压";
CM_ SG_ 2400317048 CSC_U_No_56 "CSC号";
CM_ SG_ 2400317048 CSC_Ucell_Frame_Index_56 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317048 CSC_Ucell_01_56 "01 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_02_56 "02 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_03_56 "03电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_04_56 "04  电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_05_56 "05 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_06_56 "06 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_07_56 "07  电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_08_56 "08 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_09_56 "09 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_10_56 "10 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_11_56 "11电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_12_56 "12 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_13_56 "13  电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_14_56 "14  电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_15_56 "15 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_16_56 "16 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_17_56 "17 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_18_56 "18 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_19_56 "19  电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_20_56 "20  电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_21_56 "21 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_22_56 "22 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_23_56 "23 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_24_56 "24 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_25_56 "25 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_26_56 "26 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_27_56 "27 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_28_56 "28 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_29_56 "29 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_30_56 "30 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_31_56 "31 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_32_56 "32 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_33_56 "33 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_34_56 "34 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_35_56 "35 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_36_56 "36 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_37_56 "37 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_38_56 "38 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_39_56 "39 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_40_56 "40 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_41_56 "41 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_42_56 "42 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_43_56 "43 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_44_56 "44 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_45_56 "45 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_46_56 "46 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_47_56 "47 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_48_56 "48 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_49_56 "49 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_50_56 "50 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_51_56 "51 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_52_56 "52 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_53_56 "53 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_54_56 "54 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_55_56 "55 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_56_56 "56 电池单体电压";
CM_ SG_ 2400317048 CSC_Ucell_57_56 "57 电池单体电压";
CM_ SG_ 2400317049 CSC_U_No_57 "CSC号";
CM_ SG_ 2400317049 CSC_Ucell_Frame_Index_57 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317049 CSC_Ucell_01_57 "01 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_02_57 "02 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_03_57 "03电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_04_57 "04  电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_05_57 "05 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_06_57 "06 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_07_57 "07  电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_08_57 "08 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_09_57 "09 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_10_57 "10 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_11_57 "11电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_12_57 "12 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_13_57 "13  电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_14_57 "14  电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_15_57 "15 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_16_57 "16 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_17_57 "17 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_18_57 "18 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_19_57 "19  电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_20_57 "20  电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_21_57 "21 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_22_57 "22 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_23_57 "23 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_24_57 "24 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_25_57 "25 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_26_57 "26 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_27_57 "27 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_28_57 "28 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_29_57 "29 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_30_57 "30 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_31_57 "31 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_32_57 "32 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_33_57 "33 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_34_57 "34 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_35_57 "35 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_36_57 "36 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_37_57 "37 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_38_57 "38 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_39_57 "39 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_40_57 "40 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_41_57 "41 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_42_57 "42 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_43_57 "43 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_44_57 "44 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_45_57 "45 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_46_57 "46 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_47_57 "47 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_48_57 "48 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_49_57 "49 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_50_57 "50 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_51_57 "51 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_52_57 "52 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_53_57 "53 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_54_57 "54 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_55_57 "55 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_56_57 "56 电池单体电压";
CM_ SG_ 2400317049 CSC_Ucell_57_57 "57 电池单体电压";
CM_ SG_ 2400317050 CSC_U_No_58 "CSC号";
CM_ SG_ 2400317050 CSC_Ucell_Frame_Index_58 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317050 CSC_Ucell_01_58 "01 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_02_58 "02 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_03_58 "03电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_04_58 "04  电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_05_58 "05 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_06_58 "06 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_07_58 "07  电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_08_58 "08 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_09_58 "09 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_10_58 "10 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_11_58 "11电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_12_58 "12 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_13_58 "13  电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_14_58 "14  电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_15_58 "15 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_16_58 "16 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_17_58 "17 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_18_58 "18 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_19_58 "19  电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_20_58 "20  电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_21_58 "21 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_22_58 "22 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_23_58 "23 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_24_58 "24 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_25_58 "25 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_26_58 "26 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_27_58 "27 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_28_58 "28 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_29_58 "29 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_30_58 "30 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_31_58 "31 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_32_58 "32 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_33_58 "33 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_34_58 "34 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_35_58 "35 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_36_58 "36 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_37_58 "37 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_38_58 "38 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_39_58 "39 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_40_58 "40 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_41_58 "41 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_42_58 "42 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_43_58 "43 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_44_58 "44 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_45_58 "45 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_46_58 "46 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_47_58 "47 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_48_58 "48 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_49_58 "49 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_50_58 "50 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_51_58 "51 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_52_58 "52 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_53_58 "53 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_54_58 "54 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_55_58 "55 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_56_58 "56 电池单体电压";
CM_ SG_ 2400317050 CSC_Ucell_57_58 "57 电池单体电压";
CM_ SG_ 2400317051 CSC_U_No_59 "CSC号";
CM_ SG_ 2400317051 CSC_Ucell_Frame_Index_59 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317051 CSC_Ucell_01_59 "01 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_02_59 "02 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_03_59 "03电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_04_59 "04  电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_05_59 "05 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_06_59 "06 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_07_59 "07  电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_08_59 "08 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_09_59 "09 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_10_59 "10 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_11_59 "11电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_12_59 "12 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_13_59 "13  电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_14_59 "14  电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_15_59 "15 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_16_59 "16 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_17_59 "17 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_18_59 "18 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_19_59 "19  电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_20_59 "20  电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_21_59 "21 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_22_59 "22 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_23_59 "23 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_24_59 "24 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_25_59 "25 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_26_59 "26 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_27_59 "27 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_28_59 "28 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_29_59 "29 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_30_59 "30 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_31_59 "31 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_32_59 "32 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_33_59 "33 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_34_59 "34 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_35_59 "35 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_36_59 "36 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_37_59 "37 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_38_59 "38 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_39_59 "39 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_40_59 "40 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_41_59 "41 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_42_59 "42 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_43_59 "43 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_44_59 "44 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_45_59 "45 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_46_59 "46 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_47_59 "47 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_48_59 "48 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_49_59 "49 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_50_59 "50 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_51_59 "51 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_52_59 "52 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_53_59 "53 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_54_59 "54 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_55_59 "55 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_56_59 "56 电池单体电压";
CM_ SG_ 2400317051 CSC_Ucell_57_59 "57 电池单体电压";
CM_ SG_ 2400317052 CSC_U_No_60 "CSC号";
CM_ SG_ 2400317052 CSC_Ucell_Frame_Index_60 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317052 CSC_Ucell_01_60 "01 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_02_60 "02 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_03_60 "03电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_04_60 "04  电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_05_60 "05 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_06_60 "06 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_07_60 "07  电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_08_60 "08 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_09_60 "09 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_10_60 "10 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_11_60 "11电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_12_60 "12 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_13_60 "13  电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_14_60 "14  电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_15_60 "15 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_16_60 "16 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_17_60 "17 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_18_60 "18 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_19_60 "19  电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_20_60 "20  电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_21_60 "21 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_22_60 "22 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_23_60 "23 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_24_60 "24 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_25_60 "25 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_26_60 "26 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_27_60 "27 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_28_60 "28 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_29_60 "29 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_30_60 "30 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_31_60 "31 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_32_60 "32 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_33_60 "33 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_34_60 "34 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_35_60 "35 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_36_60 "36 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_37_60 "37 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_38_60 "38 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_39_60 "39 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_40_60 "40 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_41_60 "41 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_42_60 "42 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_43_60 "43 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_44_60 "44 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_45_60 "45 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_46_60 "46 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_47_60 "47 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_48_60 "48 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_49_60 "49 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_50_60 "50 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_51_60 "51 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_52_60 "52 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_53_60 "53 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_54_60 "54 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_55_60 "55 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_56_60 "56 电池单体电压";
CM_ SG_ 2400317052 CSC_Ucell_57_60 "57 电池单体电压";
CM_ SG_ 2400317053 CSC_U_No_61 "CSC号";
CM_ SG_ 2400317053 CSC_Ucell_Frame_Index_61 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317053 CSC_Ucell_01_61 "01 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_02_61 "02 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_03_61 "03电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_04_61 "04  电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_05_61 "05 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_06_61 "06 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_07_61 "07  电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_08_61 "08 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_09_61 "09 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_10_61 "10 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_11_61 "11电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_12_61 "12 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_13_61 "13  电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_14_61 "14  电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_15_61 "15 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_16_61 "16 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_17_61 "17 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_18_61 "18 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_19_61 "19  电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_20_61 "20  电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_21_61 "21 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_22_61 "22 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_23_61 "23 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_24_61 "24 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_25_61 "25 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_26_61 "26 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_27_61 "27 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_28_61 "28 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_29_61 "29 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_30_61 "30 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_31_61 "31 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_32_61 "32 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_33_61 "33 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_34_61 "34 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_35_61 "35 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_36_61 "36 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_37_61 "37 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_38_61 "38 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_39_61 "39 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_40_61 "40 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_41_61 "41 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_42_61 "42 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_43_61 "43 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_44_61 "44 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_45_61 "45 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_46_61 "46 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_47_61 "47 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_48_61 "48 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_49_61 "49 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_50_61 "50 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_51_61 "51 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_52_61 "52 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_53_61 "53 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_54_61 "54 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_55_61 "55 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_56_61 "56 电池单体电压";
CM_ SG_ 2400317053 CSC_Ucell_57_61 "57 电池单体电压";
CM_ SG_ 2400317054 CSC_U_No_62 "CSC号";
CM_ SG_ 2400317054 CSC_Ucell_Frame_Index_62 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317054 CSC_Ucell_01_62 "01 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_02_62 "02 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_03_62 "03电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_04_62 "04  电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_05_62 "05 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_06_62 "06 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_07_62 "07  电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_08_62 "08 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_09_62 "09 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_10_62 "10 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_11_62 "11电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_12_62 "12 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_13_62 "13  电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_14_62 "14  电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_15_62 "15 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_16_62 "16 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_17_62 "17 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_18_62 "18 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_19_62 "19  电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_20_62 "20  电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_21_62 "21 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_22_62 "22 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_23_62 "23 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_24_62 "24 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_25_62 "25 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_26_62 "26 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_27_62 "27 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_28_62 "28 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_29_62 "29 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_30_62 "30 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_31_62 "31 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_32_62 "32 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_33_62 "33 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_34_62 "34 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_35_62 "35 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_36_62 "36 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_37_62 "37 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_38_62 "38 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_39_62 "39 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_40_62 "40 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_41_62 "41 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_42_62 "42 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_43_62 "43 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_44_62 "44 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_45_62 "45 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_46_62 "46 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_47_62 "47 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_48_62 "48 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_49_62 "49 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_50_62 "50 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_51_62 "51 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_52_62 "52 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_53_62 "53 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_54_62 "54 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_55_62 "55 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_56_62 "56 电池单体电压";
CM_ SG_ 2400317054 CSC_Ucell_57_62 "57 电池单体电压";
CM_ SG_ 2400317055 CSC_U_No_63 "CSC号";
CM_ SG_ 2400317055 CSC_Ucell_Frame_Index_63 "当前CSC中单体电压数据帧序号";
CM_ SG_ 2400317055 CSC_Ucell_01_63 "01 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_02_63 "02 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_03_63 "03电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_04_63 "04  电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_05_63 "05 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_06_63 "06 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_07_63 "07  电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_08_63 "08 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_09_63 "09 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_10_63 "10 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_11_63 "11电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_12_63 "12 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_13_63 "13  电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_14_63 "14  电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_15_63 "15 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_16_63 "16 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_17_63 "17 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_18_63 "18 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_19_63 "19  电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_20_63 "20  电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_21_63 "21 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_22_63 "22 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_23_63 "23 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_24_63 "24 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_25_63 "25 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_26_63 "26 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_27_63 "27 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_28_63 "28 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_29_63 "29 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_30_63 "30 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_31_63 "31 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_32_63 "32 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_33_63 "33 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_34_63 "34 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_35_63 "35 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_36_63 "36 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_37_63 "37 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_38_63 "38 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_39_63 "39 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_40_63 "40 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_41_63 "41 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_42_63 "42 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_43_63 "43 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_44_63 "44 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_45_63 "45 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_46_63 "46 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_47_63 "47 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_48_63 "48 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_49_63 "49 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_50_63 "50 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_51_63 "51 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_52_63 "52 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_53_63 "53 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_54_63 "54 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_55_63 "55 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_56_63 "56 电池单体电压";
CM_ SG_ 2400317055 CSC_Ucell_57_63 "57 电池单体电压";
CM_ SG_ 2400382529 CSC_T_No_01 "CSC号";
CM_ SG_ 2400382529 CSC_Tcell_Frame_Index_01 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382529 CSC_Tcell_01_01 "温度01";
CM_ SG_ 2400382529 CSC_Tcell_02_01 "温度02";
CM_ SG_ 2400382529 CSC_Tcell_03_01 "温度03";
CM_ SG_ 2400382529 CSC_Tcell_04_01 "温度04";
CM_ SG_ 2400382529 CSC_Tcell_05_01 "温度05";
CM_ SG_ 2400382529 CSC_Tcell_06_01 "温度06";
CM_ SG_ 2400382529 CSC_Tcell_07_01 "温度07";
CM_ SG_ 2400382529 CSC_Tcell_08_01 "温度08";
CM_ SG_ 2400382529 CSC_Tcell_09_01 "温度09";
CM_ SG_ 2400382529 CSC_Tcell_10_01 "温度10";
CM_ SG_ 2400382529 CSC_Tcell_11_01 "温度11";
CM_ SG_ 2400382529 CSC_Tcell_12_01 "温度12";
CM_ SG_ 2400382529 CSC_Tcell_13_01 "温度13";
CM_ SG_ 2400382529 CSC_Tcell_14_01 "温度14";
CM_ SG_ 2400382529 CSC_Tcell_15_01 "温度15";
CM_ SG_ 2400382529 CSC_Tcell_16_01 "温度16";
CM_ SG_ 2400382529 CSC_Tcell_17_01 "温度17";
CM_ SG_ 2400382529 CSC_Tcell_18_01 "温度18";
CM_ SG_ 2400382529 CSC_Tcell_19_01 "温度19";
CM_ SG_ 2400382529 CSC_Tcell_20_01 "温度20";
CM_ SG_ 2400382529 CSC_Tcell_21_01 "温度21";
CM_ SG_ 2400382529 CSC_Tcell_22_01 "温度22";
CM_ SG_ 2400382529 CSC_Tcell_23_01 "温度23";
CM_ SG_ 2400382529 CSC_Tcell_24_01 "温度24";
CM_ SG_ 2400382529 CSC_Tcell_25_01 "温度25";
CM_ SG_ 2400382529 CSC_Tcell_26_01 "温度26";
CM_ SG_ 2400382529 CSC_Tcell_27_01 "温度27";
CM_ SG_ 2400382529 CSC_Tcell_28_01 "温度28";
CM_ SG_ 2400382529 CSC_Tcell_29_01 "温度29";
CM_ SG_ 2400382529 CSC_Tcell_30_01 "温度30";
CM_ SG_ 2400382529 CSC_Tcell_31_01 "温度31";
CM_ SG_ 2400382529 CSC_Tcell_32_01 "温度32";
CM_ SG_ 2400382529 CSC_Tcell_33_01 "温度33";
CM_ SG_ 2400382529 CSC_Tcell_34_01 "温度34";
CM_ SG_ 2400382529 CSC_Tcell_35_01 "温度35";
CM_ SG_ 2400382529 CSC_Tcell_36_01 "温度36";
CM_ SG_ 2400382529 CSC_Tcell_37_01 "温度37";
CM_ SG_ 2400382529 CSC_Tcell_38_01 "温度38";
CM_ SG_ 2400382529 CSC_Tcell_39_01 "温度39";
CM_ SG_ 2400382529 CSC_Tcell_40_01 "温度40";
CM_ SG_ 2400382529 CSC_Tcell_41_01 "温度41";
CM_ SG_ 2400382529 CSC_Tcell_42_01 "温度42";
CM_ SG_ 2400382529 CSC_Tcell_43_01 "温度43";
CM_ SG_ 2400382529 CSC_Tcell_44_01 "温度44";
CM_ SG_ 2400382529 CSC_Tcell_45_01 "温度45";
CM_ SG_ 2400382529 CSC_Tcell_46_01 "温度46";
CM_ SG_ 2400382529 CSC_Tcell_47_01 "温度47";
CM_ SG_ 2400382529 CSC_Tcell_48_01 "温度48";
CM_ SG_ 2400382529 CSC_Tcell_49_01 "温度49";
CM_ SG_ 2400382529 CSC_Tcell_50_01 "温度50";
CM_ SG_ 2400382529 CSC_Tcell_51_01 "温度51";
CM_ SG_ 2400382529 CSC_Tcell_52_01 "温度52";
CM_ SG_ 2400382529 CSC_Tcell_53_01 "温度53";
CM_ SG_ 2400382529 CSC_Tcell_54_01 "温度54";
CM_ SG_ 2400382529 CSC_Tcell_55_01 "温度55";
CM_ SG_ 2400382529 CSC_Tcell_56_01 "温度56";
CM_ SG_ 2400382529 CSC_Tcell_57_01 "温度57";
CM_ SG_ 2400382529 CSC_Tcell_58_01 "温度58";
CM_ SG_ 2400382529 CSC_Tcell_59_01 "温度59";
CM_ SG_ 2400382529 CSC_Tcell_60_01 "温度60";
CM_ SG_ 2400382529 CSC_Tcell_61_01 "温度61";
CM_ SG_ 2400382529 CSC_Tcell_62_01 "温度62";
CM_ SG_ 2400382529 CSC_Tcell_63_01 "温度63";
CM_ SG_ 2400382529 CSC_Tcell_64_01 "温度64";
CM_ SG_ 2400382529 CSC_Tcell_65_01 "温度65";
CM_ SG_ 2400382529 CSC_Tcell_66_01 "温度66";
CM_ SG_ 2400382529 CSC_Tcell_67_01 "温度67";
CM_ SG_ 2400382529 CSC_Tcell_68_01 "温度68";
CM_ SG_ 2400382529 CSC_Tcell_69_01 "温度69";
CM_ SG_ 2400382529 CSC_Tcell_70_01 "温度70";
CM_ SG_ 2400382529 CSC_Tcell_71_01 "温度71";
CM_ SG_ 2400382529 CSC_Tcell_72_01 "温度72";
CM_ SG_ 2400382530 CSC_T_No_02 "CSC号";
CM_ SG_ 2400382530 CSC_Tcell_Frame_Index_02 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382530 CSC_Tcell_01_02 "温度01";
CM_ SG_ 2400382530 CSC_Tcell_02_02 "温度02";
CM_ SG_ 2400382530 CSC_Tcell_03_02 "温度03";
CM_ SG_ 2400382530 CSC_Tcell_04_02 "温度04";
CM_ SG_ 2400382530 CSC_Tcell_05_02 "温度05";
CM_ SG_ 2400382530 CSC_Tcell_06_02 "温度06";
CM_ SG_ 2400382530 CSC_Tcell_07_02 "温度07";
CM_ SG_ 2400382530 CSC_Tcell_08_02 "温度08";
CM_ SG_ 2400382530 CSC_Tcell_09_02 "温度09";
CM_ SG_ 2400382530 CSC_Tcell_10_02 "温度10";
CM_ SG_ 2400382530 CSC_Tcell_11_02 "温度11";
CM_ SG_ 2400382530 CSC_Tcell_12_02 "温度12";
CM_ SG_ 2400382530 CSC_Tcell_13_02 "温度13";
CM_ SG_ 2400382530 CSC_Tcell_14_02 "温度14";
CM_ SG_ 2400382530 CSC_Tcell_15_02 "温度15";
CM_ SG_ 2400382530 CSC_Tcell_16_02 "温度16";
CM_ SG_ 2400382530 CSC_Tcell_17_02 "温度17";
CM_ SG_ 2400382530 CSC_Tcell_18_02 "温度18";
CM_ SG_ 2400382530 CSC_Tcell_19_02 "温度19";
CM_ SG_ 2400382530 CSC_Tcell_20_02 "温度20";
CM_ SG_ 2400382530 CSC_Tcell_21_02 "温度21";
CM_ SG_ 2400382530 CSC_Tcell_22_02 "温度22";
CM_ SG_ 2400382530 CSC_Tcell_23_02 "温度23";
CM_ SG_ 2400382530 CSC_Tcell_24_02 "温度24";
CM_ SG_ 2400382530 CSC_Tcell_25_02 "温度25";
CM_ SG_ 2400382530 CSC_Tcell_26_02 "温度26";
CM_ SG_ 2400382530 CSC_Tcell_27_02 "温度27";
CM_ SG_ 2400382530 CSC_Tcell_28_02 "温度28";
CM_ SG_ 2400382530 CSC_Tcell_29_02 "温度29";
CM_ SG_ 2400382530 CSC_Tcell_30_02 "温度30";
CM_ SG_ 2400382530 CSC_Tcell_31_02 "温度31";
CM_ SG_ 2400382530 CSC_Tcell_32_02 "温度32";
CM_ SG_ 2400382530 CSC_Tcell_33_02 "温度33";
CM_ SG_ 2400382530 CSC_Tcell_34_02 "温度34";
CM_ SG_ 2400382530 CSC_Tcell_35_02 "温度35";
CM_ SG_ 2400382530 CSC_Tcell_36_02 "温度36";
CM_ SG_ 2400382530 CSC_Tcell_37_02 "温度37";
CM_ SG_ 2400382530 CSC_Tcell_38_02 "温度38";
CM_ SG_ 2400382530 CSC_Tcell_39_02 "温度39";
CM_ SG_ 2400382530 CSC_Tcell_40_02 "温度40";
CM_ SG_ 2400382530 CSC_Tcell_41_02 "温度41";
CM_ SG_ 2400382530 CSC_Tcell_42_02 "温度42";
CM_ SG_ 2400382530 CSC_Tcell_43_02 "温度43";
CM_ SG_ 2400382530 CSC_Tcell_44_02 "温度44";
CM_ SG_ 2400382530 CSC_Tcell_45_02 "温度45";
CM_ SG_ 2400382530 CSC_Tcell_46_02 "温度46";
CM_ SG_ 2400382530 CSC_Tcell_47_02 "温度47";
CM_ SG_ 2400382530 CSC_Tcell_48_02 "温度48";
CM_ SG_ 2400382530 CSC_Tcell_49_02 "温度49";
CM_ SG_ 2400382530 CSC_Tcell_50_02 "温度50";
CM_ SG_ 2400382530 CSC_Tcell_51_02 "温度51";
CM_ SG_ 2400382530 CSC_Tcell_52_02 "温度52";
CM_ SG_ 2400382530 CSC_Tcell_53_02 "温度53";
CM_ SG_ 2400382530 CSC_Tcell_54_02 "温度54";
CM_ SG_ 2400382530 CSC_Tcell_55_02 "温度55";
CM_ SG_ 2400382530 CSC_Tcell_56_02 "温度56";
CM_ SG_ 2400382530 CSC_Tcell_57_02 "温度57";
CM_ SG_ 2400382530 CSC_Tcell_58_02 "温度58";
CM_ SG_ 2400382530 CSC_Tcell_59_02 "温度59";
CM_ SG_ 2400382530 CSC_Tcell_60_02 "温度60";
CM_ SG_ 2400382530 CSC_Tcell_61_02 "温度61";
CM_ SG_ 2400382530 CSC_Tcell_62_02 "温度62";
CM_ SG_ 2400382530 CSC_Tcell_63_02 "温度63";
CM_ SG_ 2400382530 CSC_Tcell_64_02 "温度64";
CM_ SG_ 2400382530 CSC_Tcell_65_02 "温度65";
CM_ SG_ 2400382530 CSC_Tcell_66_02 "温度66";
CM_ SG_ 2400382530 CSC_Tcell_67_02 "温度67";
CM_ SG_ 2400382530 CSC_Tcell_68_02 "温度68";
CM_ SG_ 2400382530 CSC_Tcell_69_02 "温度69";
CM_ SG_ 2400382530 CSC_Tcell_70_02 "温度70";
CM_ SG_ 2400382530 CSC_Tcell_71_02 "温度71";
CM_ SG_ 2400382530 CSC_Tcell_72_02 "温度72";
CM_ SG_ 2400382531 CSC_T_No_03 "CSC号";
CM_ SG_ 2400382531 CSC_Tcell_Frame_Index_03 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382531 CSC_Tcell_01_03 "温度01";
CM_ SG_ 2400382531 CSC_Tcell_02_03 "温度02";
CM_ SG_ 2400382531 CSC_Tcell_03_03 "温度03";
CM_ SG_ 2400382531 CSC_Tcell_04_03 "温度04";
CM_ SG_ 2400382531 CSC_Tcell_05_03 "温度05";
CM_ SG_ 2400382531 CSC_Tcell_06_03 "温度06";
CM_ SG_ 2400382531 CSC_Tcell_07_03 "温度07";
CM_ SG_ 2400382531 CSC_Tcell_08_03 "温度08";
CM_ SG_ 2400382531 CSC_Tcell_09_03 "温度09";
CM_ SG_ 2400382531 CSC_Tcell_10_03 "温度10";
CM_ SG_ 2400382531 CSC_Tcell_11_03 "温度11";
CM_ SG_ 2400382531 CSC_Tcell_12_03 "温度12";
CM_ SG_ 2400382531 CSC_Tcell_13_03 "温度13";
CM_ SG_ 2400382531 CSC_Tcell_14_03 "温度14";
CM_ SG_ 2400382531 CSC_Tcell_15_03 "温度15";
CM_ SG_ 2400382531 CSC_Tcell_16_03 "温度16";
CM_ SG_ 2400382531 CSC_Tcell_17_03 "温度17";
CM_ SG_ 2400382531 CSC_Tcell_18_03 "温度18";
CM_ SG_ 2400382531 CSC_Tcell_19_03 "温度19";
CM_ SG_ 2400382531 CSC_Tcell_20_03 "温度20";
CM_ SG_ 2400382531 CSC_Tcell_21_03 "温度21";
CM_ SG_ 2400382531 CSC_Tcell_22_03 "温度22";
CM_ SG_ 2400382531 CSC_Tcell_23_03 "温度23";
CM_ SG_ 2400382531 CSC_Tcell_24_03 "温度24";
CM_ SG_ 2400382531 CSC_Tcell_25_03 "温度25";
CM_ SG_ 2400382531 CSC_Tcell_26_03 "温度26";
CM_ SG_ 2400382531 CSC_Tcell_27_03 "温度27";
CM_ SG_ 2400382531 CSC_Tcell_28_03 "温度28";
CM_ SG_ 2400382531 CSC_Tcell_29_03 "温度29";
CM_ SG_ 2400382531 CSC_Tcell_30_03 "温度30";
CM_ SG_ 2400382531 CSC_Tcell_31_03 "温度31";
CM_ SG_ 2400382531 CSC_Tcell_32_03 "温度32";
CM_ SG_ 2400382531 CSC_Tcell_33_03 "温度33";
CM_ SG_ 2400382531 CSC_Tcell_34_03 "温度34";
CM_ SG_ 2400382531 CSC_Tcell_35_03 "温度35";
CM_ SG_ 2400382531 CSC_Tcell_36_03 "温度36";
CM_ SG_ 2400382531 CSC_Tcell_37_03 "温度37";
CM_ SG_ 2400382531 CSC_Tcell_38_03 "温度38";
CM_ SG_ 2400382531 CSC_Tcell_39_03 "温度39";
CM_ SG_ 2400382531 CSC_Tcell_40_03 "温度40";
CM_ SG_ 2400382531 CSC_Tcell_41_03 "温度41";
CM_ SG_ 2400382531 CSC_Tcell_42_03 "温度42";
CM_ SG_ 2400382531 CSC_Tcell_43_03 "温度43";
CM_ SG_ 2400382531 CSC_Tcell_44_03 "温度44";
CM_ SG_ 2400382531 CSC_Tcell_45_03 "温度45";
CM_ SG_ 2400382531 CSC_Tcell_46_03 "温度46";
CM_ SG_ 2400382531 CSC_Tcell_47_03 "温度47";
CM_ SG_ 2400382531 CSC_Tcell_48_03 "温度48";
CM_ SG_ 2400382531 CSC_Tcell_49_03 "温度49";
CM_ SG_ 2400382531 CSC_Tcell_50_03 "温度50";
CM_ SG_ 2400382531 CSC_Tcell_51_03 "温度51";
CM_ SG_ 2400382531 CSC_Tcell_52_03 "温度52";
CM_ SG_ 2400382531 CSC_Tcell_53_03 "温度53";
CM_ SG_ 2400382531 CSC_Tcell_54_03 "温度54";
CM_ SG_ 2400382531 CSC_Tcell_55_03 "温度55";
CM_ SG_ 2400382531 CSC_Tcell_56_03 "温度56";
CM_ SG_ 2400382531 CSC_Tcell_57_03 "温度57";
CM_ SG_ 2400382531 CSC_Tcell_58_03 "温度58";
CM_ SG_ 2400382531 CSC_Tcell_59_03 "温度59";
CM_ SG_ 2400382531 CSC_Tcell_60_03 "温度60";
CM_ SG_ 2400382531 CSC_Tcell_61_03 "温度61";
CM_ SG_ 2400382531 CSC_Tcell_62_03 "温度62";
CM_ SG_ 2400382531 CSC_Tcell_63_03 "温度63";
CM_ SG_ 2400382531 CSC_Tcell_64_03 "温度64";
CM_ SG_ 2400382531 CSC_Tcell_65_03 "温度65";
CM_ SG_ 2400382531 CSC_Tcell_66_03 "温度66";
CM_ SG_ 2400382531 CSC_Tcell_67_03 "温度67";
CM_ SG_ 2400382531 CSC_Tcell_68_03 "温度68";
CM_ SG_ 2400382531 CSC_Tcell_69_03 "温度69";
CM_ SG_ 2400382531 CSC_Tcell_70_03 "温度70";
CM_ SG_ 2400382531 CSC_Tcell_71_03 "温度71";
CM_ SG_ 2400382531 CSC_Tcell_72_03 "温度72";
VAL_ 2400317040 CSC_U_No_48 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317040 CSC_Ucell_01_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_02_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_03_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_04_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_05_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_06_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_07_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_08_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_09_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_10_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_11_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_12_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_13_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_14_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_15_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_16_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_17_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_18_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_19_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_20_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_21_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_22_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_23_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_24_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_25_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_26_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_27_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_28_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_29_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_30_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_31_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_32_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_33_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_34_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_35_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_36_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_37_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_38_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_39_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_40_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_41_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_42_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_43_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_44_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_45_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_46_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_47_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_48_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_49_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_50_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_51_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_52_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_53_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_54_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_55_48 65535 "Invalid" ;
VAL_ 2400317040 CSC_Ucell_56_48 65535 "Invalid" ;
VAL_ 2400317041 CSC_U_No_49 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317041 CSC_Ucell_01_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_02_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_03_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_04_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_05_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_06_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_07_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_08_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_09_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_10_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_11_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_12_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_13_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_14_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_15_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_16_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_17_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_18_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_19_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_20_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_21_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_22_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_23_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_24_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_25_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_26_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_27_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_28_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_29_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_30_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_31_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_32_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_33_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_34_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_35_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_36_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_37_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_38_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_39_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_40_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_41_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_42_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_43_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_44_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_45_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_46_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_47_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_48_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_49_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_50_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_51_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_52_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_53_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_54_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_55_49 65535 "Invalid" ;
VAL_ 2400317041 CSC_Ucell_56_49 65535 "Invalid" ;
VAL_ 2400317042 CSC_U_No_50 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317042 CSC_Ucell_01_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_02_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_03_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_04_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_05_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_06_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_07_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_08_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_09_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_10_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_11_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_12_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_13_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_14_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_15_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_16_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_17_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_18_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_19_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_20_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_21_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_22_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_23_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_24_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_25_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_26_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_27_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_28_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_29_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_30_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_31_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_32_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_33_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_34_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_35_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_36_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_37_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_38_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_39_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_40_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_41_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_42_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_43_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_44_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_45_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_46_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_47_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_48_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_49_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_50_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_51_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_52_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_53_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_54_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_55_50 65535 "Invalid" ;
VAL_ 2400317042 CSC_Ucell_56_50 65535 "Invalid" ;
VAL_ 2400317043 CSC_U_No_51 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317043 CSC_Ucell_01_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_02_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_03_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_04_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_05_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_06_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_07_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_08_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_09_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_10_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_11_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_12_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_13_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_14_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_15_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_16_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_17_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_18_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_19_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_20_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_21_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_22_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_23_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_24_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_25_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_26_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_27_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_28_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_29_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_30_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_31_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_32_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_33_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_34_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_35_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_36_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_37_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_38_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_39_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_40_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_41_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_42_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_43_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_44_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_45_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_46_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_47_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_48_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_49_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_50_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_51_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_52_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_53_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_54_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_55_51 65535 "Invalid" ;
VAL_ 2400317043 CSC_Ucell_56_51 65535 "Invalid" ;
VAL_ 2400317044 CSC_U_No_52 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317044 CSC_Ucell_01_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_02_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_03_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_04_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_05_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_06_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_07_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_08_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_09_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_10_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_11_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_12_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_13_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_14_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_15_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_16_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_17_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_18_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_19_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_20_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_21_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_22_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_23_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_24_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_25_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_26_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_27_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_28_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_29_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_30_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_31_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_32_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_33_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_34_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_35_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_36_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_37_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_38_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_39_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_40_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_41_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_42_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_43_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_44_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_45_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_46_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_47_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_48_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_49_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_50_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_51_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_52_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_53_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_54_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_55_52 65535 "Invalid" ;
VAL_ 2400317044 CSC_Ucell_56_52 65535 "Invalid" ;
VAL_ 2400317045 CSC_U_No_53 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317045 CSC_Ucell_01_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_02_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_03_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_04_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_05_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_06_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_07_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_08_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_09_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_10_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_11_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_12_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_13_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_14_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_15_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_16_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_17_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_18_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_19_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_20_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_21_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_22_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_23_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_24_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_25_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_26_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_27_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_28_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_29_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_30_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_31_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_32_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_33_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_34_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_35_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_36_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_37_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_38_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_39_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_40_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_41_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_42_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_43_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_44_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_45_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_46_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_47_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_48_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_49_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_50_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_51_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_52_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_53_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_54_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_55_53 65535 "Invalid" ;
VAL_ 2400317045 CSC_Ucell_56_53 65535 "Invalid" ;
VAL_ 2400317046 CSC_U_No_54 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317046 CSC_Ucell_01_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_02_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_03_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_04_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_05_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_06_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_07_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_08_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_09_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_10_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_11_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_12_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_13_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_14_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_15_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_16_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_17_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_18_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_19_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_20_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_21_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_22_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_23_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_24_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_25_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_26_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_27_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_28_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_29_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_30_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_31_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_32_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_33_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_34_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_35_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_36_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_37_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_38_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_39_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_40_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_41_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_42_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_43_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_44_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_45_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_46_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_47_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_48_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_49_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_50_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_51_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_52_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_53_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_54_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_55_54 65535 "Invalid" ;
VAL_ 2400317046 CSC_Ucell_56_54 65535 "Invalid" ;
VAL_ 2400317047 CSC_U_No_55 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317047 CSC_Ucell_01_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_02_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_03_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_04_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_05_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_06_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_07_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_08_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_09_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_10_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_11_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_12_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_13_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_14_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_15_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_16_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_17_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_18_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_19_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_20_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_21_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_22_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_23_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_24_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_25_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_26_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_27_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_28_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_29_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_30_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_31_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_32_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_33_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_34_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_35_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_36_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_37_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_38_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_39_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_40_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_41_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_42_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_43_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_44_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_45_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_46_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_47_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_48_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_49_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_50_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_51_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_52_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_53_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_54_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_55_55 65535 "Invalid" ;
VAL_ 2400317047 CSC_Ucell_56_55 65535 "Invalid" ;
VAL_ 2400317048 CSC_U_No_56 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317048 CSC_Ucell_01_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_02_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_03_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_04_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_05_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_06_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_07_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_08_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_09_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_10_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_11_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_12_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_13_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_14_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_15_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_16_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_17_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_18_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_19_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_20_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_21_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_22_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_23_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_24_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_25_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_26_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_27_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_28_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_29_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_30_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_31_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_32_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_33_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_34_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_35_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_36_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_37_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_38_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_39_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_40_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_41_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_42_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_43_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_44_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_45_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_46_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_47_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_48_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_49_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_50_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_51_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_52_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_53_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_54_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_55_56 65535 "Invalid" ;
VAL_ 2400317048 CSC_Ucell_56_56 65535 "Invalid" ;
VAL_ 2400317049 CSC_U_No_57 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317049 CSC_Ucell_01_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_02_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_03_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_04_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_05_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_06_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_07_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_08_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_09_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_10_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_11_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_12_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_13_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_14_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_15_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_16_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_17_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_18_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_19_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_20_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_21_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_22_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_23_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_24_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_25_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_26_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_27_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_28_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_29_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_30_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_31_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_32_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_33_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_34_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_35_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_36_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_37_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_38_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_39_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_40_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_41_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_42_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_43_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_44_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_45_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_46_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_47_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_48_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_49_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_50_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_51_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_52_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_53_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_54_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_55_57 65535 "Invalid" ;
VAL_ 2400317049 CSC_Ucell_56_57 65535 "Invalid" ;
VAL_ 2400317050 CSC_U_No_58 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317050 CSC_Ucell_01_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_02_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_03_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_04_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_05_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_06_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_07_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_08_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_09_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_10_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_11_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_12_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_13_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_14_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_15_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_16_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_17_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_18_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_19_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_20_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_21_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_22_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_23_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_24_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_25_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_26_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_27_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_28_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_29_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_30_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_31_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_32_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_33_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_34_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_35_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_36_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_37_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_38_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_39_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_40_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_41_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_42_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_43_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_44_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_45_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_46_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_47_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_48_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_49_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_50_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_51_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_52_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_53_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_54_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_55_58 65535 "Invalid" ;
VAL_ 2400317050 CSC_Ucell_56_58 65535 "Invalid" ;
VAL_ 2400317051 CSC_U_No_59 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317051 CSC_Ucell_01_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_02_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_03_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_04_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_05_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_06_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_07_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_08_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_09_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_10_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_11_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_12_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_13_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_14_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_15_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_16_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_17_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_18_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_19_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_20_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_21_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_22_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_23_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_24_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_25_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_26_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_27_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_28_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_29_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_30_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_31_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_32_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_33_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_34_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_35_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_36_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_37_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_38_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_39_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_40_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_41_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_42_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_43_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_44_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_45_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_46_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_47_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_48_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_49_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_50_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_51_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_52_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_53_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_54_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_55_59 65535 "Invalid" ;
VAL_ 2400317051 CSC_Ucell_56_59 65535 "Invalid" ;
VAL_ 2400317052 CSC_U_No_60 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317052 CSC_Ucell_01_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_02_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_03_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_04_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_05_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_06_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_07_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_08_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_09_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_10_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_11_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_12_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_13_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_14_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_15_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_16_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_17_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_18_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_19_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_20_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_21_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_22_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_23_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_24_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_25_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_26_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_27_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_28_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_29_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_30_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_31_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_32_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_33_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_34_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_35_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_36_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_37_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_38_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_39_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_40_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_41_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_42_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_43_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_44_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_45_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_46_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_47_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_48_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_49_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_50_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_51_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_52_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_53_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_54_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_55_60 65535 "Invalid" ;
VAL_ 2400317052 CSC_Ucell_56_60 65535 "Invalid" ;
VAL_ 2400317053 CSC_U_No_61 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317053 CSC_Ucell_01_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_02_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_03_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_04_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_05_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_06_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_07_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_08_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_09_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_10_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_11_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_12_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_13_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_14_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_15_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_16_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_17_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_18_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_19_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_20_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_21_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_22_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_23_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_24_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_25_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_26_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_27_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_28_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_29_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_30_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_31_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_32_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_33_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_34_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_35_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_36_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_37_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_38_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_39_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_40_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_41_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_42_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_43_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_44_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_45_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_46_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_47_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_48_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_49_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_50_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_51_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_52_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_53_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_54_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_55_61 65535 "Invalid" ;
VAL_ 2400317053 CSC_Ucell_56_61 65535 "Invalid" ;
VAL_ 2400317054 CSC_U_No_62 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317054 CSC_Ucell_01_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_02_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_03_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_04_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_05_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_06_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_07_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_08_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_09_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_10_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_11_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_12_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_13_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_14_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_15_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_16_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_17_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_18_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_19_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_20_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_21_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_22_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_23_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_24_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_25_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_26_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_27_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_28_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_29_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_30_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_31_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_32_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_33_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_34_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_35_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_36_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_37_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_38_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_39_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_40_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_41_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_42_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_43_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_44_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_45_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_46_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_47_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_48_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_49_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_50_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_51_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_52_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_53_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_54_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_55_62 65535 "Invalid" ;
VAL_ 2400317054 CSC_Ucell_56_62 65535 "Invalid" ;
VAL_ 2400317055 CSC_U_No_63 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400317055 CSC_Ucell_01_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_02_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_03_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_04_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_05_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_06_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_07_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_08_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_09_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_10_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_11_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_12_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_13_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_14_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_15_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_16_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_17_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_18_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_19_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_20_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_21_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_22_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_23_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_24_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_25_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_26_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_27_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_28_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_29_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_30_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_31_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_32_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_33_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_34_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_35_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_36_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_37_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_38_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_39_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_40_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_41_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_42_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_43_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_44_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_45_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_46_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_47_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_48_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_49_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_50_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_51_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_52_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_53_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_54_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_55_63 65535 "Invalid" ;
VAL_ 2400317055 CSC_Ucell_56_63 65535 "Invalid" ;
VAL_ 2400382529 CSC_T_No_01 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382529 CSC_Tcell_01_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_02_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_03_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_04_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_05_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_06_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_07_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_08_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_09_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_10_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_11_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_12_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_13_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_14_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_15_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_16_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_17_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_18_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_19_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_20_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_21_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_22_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_23_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_24_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_25_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_26_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_27_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_28_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_29_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_30_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_31_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_32_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_33_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_34_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_35_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_36_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_37_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_38_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_39_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_40_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_41_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_42_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_43_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_44_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_45_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_46_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_47_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_48_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_49_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_50_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_51_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_52_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_53_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_54_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_55_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_56_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_57_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_58_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_59_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_60_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_61_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_62_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_63_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_64_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_65_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_66_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_67_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_68_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_69_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_70_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_71_01 255 "Invalid" ;
VAL_ 2400382529 CSC_Tcell_72_01 255 "Invalid" ;
VAL_ 2400382530 CSC_T_No_02 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382530 CSC_Tcell_01_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_02_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_03_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_04_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_05_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_06_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_07_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_08_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_09_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_10_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_11_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_12_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_13_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_14_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_15_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_16_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_17_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_18_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_19_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_20_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_21_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_22_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_23_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_24_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_25_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_26_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_27_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_28_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_29_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_30_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_31_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_32_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_33_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_34_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_35_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_36_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_37_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_38_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_39_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_40_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_41_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_42_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_43_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_44_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_45_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_46_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_47_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_48_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_49_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_50_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_51_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_52_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_53_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_54_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_55_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_56_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_57_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_58_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_59_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_60_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_61_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_62_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_63_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_64_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_65_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_66_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_67_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_68_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_69_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_70_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_71_02 255 "Invalid" ;
VAL_ 2400382530 CSC_Tcell_72_02 255 "Invalid" ;
VAL_ 2400382531 CSC_T_No_03 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382531 CSC_Tcell_01_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_02_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_03_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_04_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_05_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_06_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_07_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_08_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_09_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_10_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_11_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_12_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_13_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_14_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_15_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_16_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_17_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_18_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_19_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_20_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_21_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_22_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_23_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_24_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_25_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_26_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_27_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_28_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_29_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_30_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_31_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_32_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_33_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_34_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_35_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_36_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_37_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_38_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_39_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_40_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_41_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_42_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_43_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_44_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_45_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_46_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_47_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_48_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_49_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_50_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_51_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_52_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_53_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_54_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_55_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_56_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_57_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_58_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_59_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_60_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_61_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_62_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_63_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_64_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_65_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_66_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_67_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_68_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_69_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_70_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_71_03 255 "Invalid" ;
VAL_ 2400382531 CSC_Tcell_72_03 255 "Invalid" ;
