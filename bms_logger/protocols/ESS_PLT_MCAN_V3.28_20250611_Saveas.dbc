VERSION ""

NS_ :

BS_:

BU_: MBMU PC SBMU IMM ETH DCDC LEMS

BO_ 2400382566 S2P_Detail_Tcell1__38: 8 SBMU
 SG_ CSC_T_No_38 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_38 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_38 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_38 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_38 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_38 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_38 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_38 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_38 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_38 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_38 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_38 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_38 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_38 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_38 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_38 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_38 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_38 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_38 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_38 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_38 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_38 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_38 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_38 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_38 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_38 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_38 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_38 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_38 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_38 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_38 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_38 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_38 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_38 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_38 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_38 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_38 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_38 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_38 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_38 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_38 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_38 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_38 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_38 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_38 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_38 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_38 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_38 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_38 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_38 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_38 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_38 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_38 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_38 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_38 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_38 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_38 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_38 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_38 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_38 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_38 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_38 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_38 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_38 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_38 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_38 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_38 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_38 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_38 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_38 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_38 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_38 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_38 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_38 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382567 S2P_Detail_Tcell1__39: 8 SBMU
 SG_ CSC_T_No_39 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_39 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_39 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_39 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_39 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_39 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_39 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_39 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_39 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_39 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_39 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_39 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_39 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_39 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_39 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_39 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_39 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_39 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_39 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_39 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_39 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_39 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_39 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_39 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_39 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_39 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_39 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_39 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_39 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_39 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_39 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_39 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_39 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_39 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_39 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_39 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_39 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_39 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_39 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_39 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_39 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_39 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_39 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_39 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_39 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_39 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_39 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_39 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_39 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_39 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_39 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_39 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_39 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_39 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_39 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_39 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_39 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_39 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_39 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_39 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_39 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_39 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_39 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_39 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_39 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_39 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_39 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_39 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_39 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_39 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_39 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_39 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_39 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_39 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382568 S2P_Detail_Tcell1__40: 8 SBMU
 SG_ CSC_T_No_40 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_40 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_40 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_40 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_40 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_40 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_40 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_40 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_40 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_40 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_40 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_40 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_40 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_40 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_40 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_40 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_40 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_40 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_40 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_40 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_40 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_40 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_40 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_40 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_40 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_40 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_40 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_40 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_40 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_40 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_40 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_40 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_40 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_40 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_40 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_40 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_40 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_40 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_40 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_40 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_40 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_40 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_40 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_40 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_40 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_40 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_40 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_40 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_40 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_40 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_40 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_40 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_40 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_40 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_40 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_40 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_40 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_40 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_40 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_40 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_40 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_40 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_40 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_40 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_40 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_40 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_40 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_40 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_40 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_40 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_40 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_40 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_40 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_40 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382569 S2P_Detail_Tcell1__41: 8 SBMU
 SG_ CSC_T_No_41 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_41 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_41 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_41 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_41 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_41 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_41 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_41 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_41 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_41 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_41 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_41 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_41 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_41 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_41 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_41 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_41 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_41 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_41 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_41 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_41 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_41 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_41 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_41 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_41 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_41 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_41 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_41 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_41 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_41 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_41 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_41 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_41 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_41 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_41 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_41 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_41 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_41 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_41 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_41 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_41 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_41 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_41 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_41 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_41 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_41 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_41 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_41 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_41 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_41 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_41 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_41 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_41 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_41 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_41 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_41 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_41 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_41 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_41 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_41 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_41 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_41 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_41 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_41 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_41 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_41 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_41 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_41 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_41 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_41 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_41 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_41 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_41 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_41 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382570 S2P_Detail_Tcell1__42: 8 SBMU
 SG_ CSC_T_No_42 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_42 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_42 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_42 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_42 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_42 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_42 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_42 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_42 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_42 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_42 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_42 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_42 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_42 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_42 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_42 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_42 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_42 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_42 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_42 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_42 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_42 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_42 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_42 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_42 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_42 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_42 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_42 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_42 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_42 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_42 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_42 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_42 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_42 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_42 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_42 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_42 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_42 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_42 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_42 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_42 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_42 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_42 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_42 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_42 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_42 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_42 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_42 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_42 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_42 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_42 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_42 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_42 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_42 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_42 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_42 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_42 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_42 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_42 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_42 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_42 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_42 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_42 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_42 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_42 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_42 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_42 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_42 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_42 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_42 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_42 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_42 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_42 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_42 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382571 S2P_Detail_Tcell1__43: 8 SBMU
 SG_ CSC_T_No_43 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_43 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_43 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_43 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_43 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_43 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_43 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_43 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_43 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_43 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_43 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_43 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_43 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_43 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_43 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_43 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_43 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_43 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_43 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_43 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_43 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_43 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_43 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_43 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_43 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_43 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_43 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_43 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_43 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_43 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_43 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_43 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_43 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_43 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_43 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_43 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_43 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_43 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_43 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_43 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_43 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_43 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_43 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_43 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_43 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_43 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_43 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_43 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_43 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_43 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_43 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_43 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_43 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_43 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_43 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_43 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_43 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_43 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_43 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_43 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_43 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_43 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_43 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_43 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_43 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_43 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_43 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_43 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_43 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_43 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_43 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_43 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_43 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_43 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382572 S2P_Detail_Tcell1__44: 8 SBMU
 SG_ CSC_T_No_44 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_44 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_44 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_44 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_44 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_44 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_44 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_44 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_44 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_44 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_44 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_44 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_44 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_44 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_44 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_44 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_44 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_44 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_44 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_44 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_44 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_44 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_44 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_44 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_44 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_44 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_44 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_44 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_44 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_44 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_44 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_44 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_44 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_44 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_44 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_44 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_44 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_44 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_44 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_44 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_44 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_44 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_44 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_44 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_44 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_44 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_44 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_44 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_44 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_44 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_44 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_44 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_44 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_44 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_44 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_44 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_44 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_44 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_44 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_44 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_44 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_44 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_44 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_44 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_44 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_44 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_44 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_44 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_44 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_44 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_44 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_44 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_44 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_44 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382573 S2P_Detail_Tcell1__45: 8 SBMU
 SG_ CSC_T_No_45 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_45 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_45 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_45 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_45 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_45 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_45 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_45 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_45 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_45 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_45 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_45 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_45 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_45 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_45 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_45 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_45 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_45 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_45 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_45 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_45 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_45 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_45 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_45 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_45 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_45 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_45 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_45 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_45 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_45 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_45 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_45 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_45 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_45 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_45 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_45 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_45 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_45 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_45 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_45 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_45 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_45 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_45 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_45 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_45 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_45 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_45 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_45 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_45 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_45 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_45 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_45 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_45 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_45 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_45 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_45 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_45 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_45 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_45 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_45 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_45 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_45 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_45 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_45 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_45 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_45 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_45 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_45 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_45 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_45 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_45 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_45 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_45 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_45 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382574 S2P_Detail_Tcell1__46: 8 SBMU
 SG_ CSC_T_No_46 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_46 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_46 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_46 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_46 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_46 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_46 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_46 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_46 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_46 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_46 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_46 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_46 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_46 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_46 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_46 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_46 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_46 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_46 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_46 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_46 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_46 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_46 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_46 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_46 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_46 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_46 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_46 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_46 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_46 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_46 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_46 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_46 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_46 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_46 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_46 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_46 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_46 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_46 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_46 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_46 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_46 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_46 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_46 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_46 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_46 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_46 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_46 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_46 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_46 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_46 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_46 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_46 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_46 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_46 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_46 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_46 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_46 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_46 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_46 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_46 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_46 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_46 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_46 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_46 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_46 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_46 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_46 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_46 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_46 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_46 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_46 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_46 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_46 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382575 S2P_Detail_Tcell1__47: 8 SBMU
 SG_ CSC_T_No_47 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_47 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_47 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_47 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_47 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_47 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_47 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_47 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_47 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_47 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_47 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_47 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_47 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_47 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_47 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_47 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_47 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_47 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_47 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_47 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_47 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_47 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_47 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_47 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_47 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_47 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_47 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_47 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_47 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_47 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_47 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_47 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_47 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_47 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_47 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_47 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_47 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_47 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_47 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_47 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_47 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_47 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_47 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_47 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_47 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_47 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_47 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_47 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_47 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_47 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_47 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_47 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_47 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_47 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_47 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_47 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_47 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_47 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_47 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_47 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_47 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_47 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_47 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_47 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_47 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_47 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_47 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_47 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_47 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_47 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_47 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_47 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_47 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_47 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382576 S2P_Detail_Tcell1__48: 8 SBMU
 SG_ CSC_T_No_48 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_48 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_48 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_48 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_48 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_48 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_48 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_48 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_48 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_48 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_48 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_48 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_48 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_48 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_48 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_48 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_48 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_48 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_48 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_48 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_48 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_48 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_48 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_48 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_48 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_48 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_48 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_48 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_48 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_48 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_48 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_48 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_48 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_48 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_48 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_48 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_48 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_48 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_48 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_48 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_48 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_48 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_48 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_48 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_48 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_48 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_48 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_48 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_48 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_48 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_48 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_48 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_48 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_48 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_48 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_48 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_48 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_48 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_48 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_48 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_48 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_48 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_48 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_48 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_48 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_48 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_48 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_48 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_48 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_48 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_48 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_48 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_48 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_48 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382577 S2P_Detail_Tcell1__49: 8 SBMU
 SG_ CSC_T_No_49 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_49 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_49 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_49 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_49 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_49 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_49 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_49 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_49 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_49 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_49 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_49 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_49 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_49 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_49 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_49 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_49 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_49 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_49 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_49 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_49 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_49 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_49 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_49 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_49 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_49 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_49 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_49 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_49 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_49 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_49 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_49 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_49 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_49 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_49 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_49 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_49 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_49 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_49 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_49 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_49 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_49 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_49 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_49 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_49 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_49 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_49 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_49 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_49 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_49 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_49 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_49 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_49 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_49 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_49 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_49 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_49 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_49 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_49 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_49 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_49 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_49 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_49 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_49 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_49 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_49 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_49 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_49 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_49 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_49 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_49 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_49 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_49 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_49 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382578 S2P_Detail_Tcell1__50: 8 SBMU
 SG_ CSC_T_No_50 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_50 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_50 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_50 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_50 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_50 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_50 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_50 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_50 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_50 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_50 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_50 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_50 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_50 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_50 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_50 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_50 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_50 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_50 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_50 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_50 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_50 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_50 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_50 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_50 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_50 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_50 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_50 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_50 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_50 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_50 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_50 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_50 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_50 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_50 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_50 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_50 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_50 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_50 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_50 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_50 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_50 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_50 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_50 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_50 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_50 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_50 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_50 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_50 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_50 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_50 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_50 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_50 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_50 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_50 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_50 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_50 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_50 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_50 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_50 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_50 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_50 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_50 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_50 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_50 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_50 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_50 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_50 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_50 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_50 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_50 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_50 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_50 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_50 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382579 S2P_Detail_Tcell1__51: 8 SBMU
 SG_ CSC_T_No_51 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_51 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_51 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_51 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_51 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_51 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_51 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_51 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_51 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_51 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_51 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_51 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_51 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_51 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_51 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_51 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_51 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_51 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_51 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_51 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_51 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_51 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_51 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_51 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_51 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_51 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_51 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_51 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_51 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_51 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_51 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_51 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_51 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_51 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_51 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_51 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_51 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_51 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_51 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_51 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_51 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_51 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_51 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_51 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_51 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_51 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_51 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_51 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_51 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_51 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_51 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_51 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_51 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_51 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_51 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_51 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_51 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_51 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_51 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_51 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_51 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_51 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_51 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_51 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_51 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_51 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_51 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_51 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_51 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_51 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_51 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_51 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_51 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_51 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382580 S2P_Detail_Tcell1__52: 8 SBMU
 SG_ CSC_T_No_52 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_52 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_52 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_52 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_52 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_52 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_52 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_52 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_52 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_52 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_52 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_52 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_52 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_52 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_52 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_52 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_52 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_52 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_52 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_52 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_52 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_52 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_52 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_52 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_52 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_52 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_52 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_52 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_52 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_52 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_52 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_52 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_52 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_52 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_52 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_52 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_52 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_52 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_52 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_52 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_52 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_52 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_52 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_52 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_52 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_52 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_52 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_52 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_52 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_52 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_52 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_52 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_52 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_52 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_52 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_52 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_52 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_52 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_52 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_52 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_52 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_52 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_52 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_52 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_52 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_52 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_52 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_52 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_52 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_52 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_52 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_52 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_52 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_52 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382581 S2P_Detail_Tcell1__53: 8 SBMU
 SG_ CSC_T_No_53 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_53 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_53 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_53 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_53 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_53 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_53 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_53 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_53 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_53 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_53 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_53 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_53 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_53 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_53 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_53 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_53 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_53 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_53 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_53 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_53 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_53 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_53 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_53 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_53 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_53 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_53 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_53 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_53 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_53 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_53 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_53 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_53 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_53 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_53 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_53 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_53 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_53 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_53 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_53 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_53 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_53 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_53 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_53 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_53 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_53 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_53 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_53 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_53 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_53 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_53 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_53 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_53 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_53 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_53 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_53 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_53 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_53 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_53 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_53 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_53 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_53 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_53 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_53 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_53 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_53 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_53 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_53 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_53 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_53 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_53 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_53 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_53 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_53 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382582 S2P_Detail_Tcell1__54: 8 SBMU
 SG_ CSC_T_No_54 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_54 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_54 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_54 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_54 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_54 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_54 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_54 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_54 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_54 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_54 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_54 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_54 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_54 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_54 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_54 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_54 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_54 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_54 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_54 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_54 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_54 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_54 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_54 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_54 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_54 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_54 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_54 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_54 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_54 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_54 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_54 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_54 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_54 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_54 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_54 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_54 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_54 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_54 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_54 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_54 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_54 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_54 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_54 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_54 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_54 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_54 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_54 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_54 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_54 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_54 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_54 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_54 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_54 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_54 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_54 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_54 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_54 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_54 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_54 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_54 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_54 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_54 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_54 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_54 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_54 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_54 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_54 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_54 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_54 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_54 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_54 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_54 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_54 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

CM_ SG_ 2400382566 CSC_T_No_38 "CSC号";
CM_ SG_ 2400382566 CSC_Tcell_Frame_Index_38 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382566 CSC_Tcell_01_38 "温度01";
CM_ SG_ 2400382566 CSC_Tcell_02_38 "温度02";
CM_ SG_ 2400382566 CSC_Tcell_03_38 "温度03";
CM_ SG_ 2400382566 CSC_Tcell_04_38 "温度04";
CM_ SG_ 2400382566 CSC_Tcell_05_38 "温度05";
CM_ SG_ 2400382566 CSC_Tcell_06_38 "温度06";
CM_ SG_ 2400382566 CSC_Tcell_07_38 "温度07";
CM_ SG_ 2400382566 CSC_Tcell_08_38 "温度08";
CM_ SG_ 2400382566 CSC_Tcell_09_38 "温度09";
CM_ SG_ 2400382566 CSC_Tcell_10_38 "温度10";
CM_ SG_ 2400382566 CSC_Tcell_11_38 "温度11";
CM_ SG_ 2400382566 CSC_Tcell_12_38 "温度12";
CM_ SG_ 2400382566 CSC_Tcell_13_38 "温度13";
CM_ SG_ 2400382566 CSC_Tcell_14_38 "温度14";
CM_ SG_ 2400382566 CSC_Tcell_15_38 "温度15";
CM_ SG_ 2400382566 CSC_Tcell_16_38 "温度16";
CM_ SG_ 2400382566 CSC_Tcell_17_38 "温度17";
CM_ SG_ 2400382566 CSC_Tcell_18_38 "温度18";
CM_ SG_ 2400382566 CSC_Tcell_19_38 "温度19";
CM_ SG_ 2400382566 CSC_Tcell_20_38 "温度20";
CM_ SG_ 2400382566 CSC_Tcell_21_38 "温度21";
CM_ SG_ 2400382566 CSC_Tcell_22_38 "温度22";
CM_ SG_ 2400382566 CSC_Tcell_23_38 "温度23";
CM_ SG_ 2400382566 CSC_Tcell_24_38 "温度24";
CM_ SG_ 2400382566 CSC_Tcell_25_38 "温度25";
CM_ SG_ 2400382566 CSC_Tcell_26_38 "温度26";
CM_ SG_ 2400382566 CSC_Tcell_27_38 "温度27";
CM_ SG_ 2400382566 CSC_Tcell_28_38 "温度28";
CM_ SG_ 2400382566 CSC_Tcell_29_38 "温度29";
CM_ SG_ 2400382566 CSC_Tcell_30_38 "温度30";
CM_ SG_ 2400382566 CSC_Tcell_31_38 "温度31";
CM_ SG_ 2400382566 CSC_Tcell_32_38 "温度32";
CM_ SG_ 2400382566 CSC_Tcell_33_38 "温度33";
CM_ SG_ 2400382566 CSC_Tcell_34_38 "温度34";
CM_ SG_ 2400382566 CSC_Tcell_35_38 "温度35";
CM_ SG_ 2400382566 CSC_Tcell_36_38 "温度36";
CM_ SG_ 2400382566 CSC_Tcell_37_38 "温度37";
CM_ SG_ 2400382566 CSC_Tcell_38_38 "温度38";
CM_ SG_ 2400382566 CSC_Tcell_39_38 "温度39";
CM_ SG_ 2400382566 CSC_Tcell_40_38 "温度40";
CM_ SG_ 2400382566 CSC_Tcell_41_38 "温度41";
CM_ SG_ 2400382566 CSC_Tcell_42_38 "温度42";
CM_ SG_ 2400382566 CSC_Tcell_43_38 "温度43";
CM_ SG_ 2400382566 CSC_Tcell_44_38 "温度44";
CM_ SG_ 2400382566 CSC_Tcell_45_38 "温度45";
CM_ SG_ 2400382566 CSC_Tcell_46_38 "温度46";
CM_ SG_ 2400382566 CSC_Tcell_47_38 "温度47";
CM_ SG_ 2400382566 CSC_Tcell_48_38 "温度48";
CM_ SG_ 2400382566 CSC_Tcell_49_38 "温度49";
CM_ SG_ 2400382566 CSC_Tcell_50_38 "温度50";
CM_ SG_ 2400382566 CSC_Tcell_51_38 "温度51";
CM_ SG_ 2400382566 CSC_Tcell_52_38 "温度52";
CM_ SG_ 2400382566 CSC_Tcell_53_38 "温度53";
CM_ SG_ 2400382566 CSC_Tcell_54_38 "温度54";
CM_ SG_ 2400382566 CSC_Tcell_55_38 "温度55";
CM_ SG_ 2400382566 CSC_Tcell_56_38 "温度56";
CM_ SG_ 2400382566 CSC_Tcell_57_38 "温度57";
CM_ SG_ 2400382566 CSC_Tcell_58_38 "温度58";
CM_ SG_ 2400382566 CSC_Tcell_59_38 "温度59";
CM_ SG_ 2400382566 CSC_Tcell_60_38 "温度60";
CM_ SG_ 2400382566 CSC_Tcell_61_38 "温度61";
CM_ SG_ 2400382566 CSC_Tcell_62_38 "温度62";
CM_ SG_ 2400382566 CSC_Tcell_63_38 "温度63";
CM_ SG_ 2400382566 CSC_Tcell_64_38 "温度64";
CM_ SG_ 2400382566 CSC_Tcell_65_38 "温度65";
CM_ SG_ 2400382566 CSC_Tcell_66_38 "温度66";
CM_ SG_ 2400382566 CSC_Tcell_67_38 "温度67";
CM_ SG_ 2400382566 CSC_Tcell_68_38 "温度68";
CM_ SG_ 2400382566 CSC_Tcell_69_38 "温度69";
CM_ SG_ 2400382566 CSC_Tcell_70_38 "温度70";
CM_ SG_ 2400382566 CSC_Tcell_71_38 "温度71";
CM_ SG_ 2400382566 CSC_Tcell_72_38 "温度72";
CM_ SG_ 2400382567 CSC_T_No_39 "CSC号";
CM_ SG_ 2400382567 CSC_Tcell_Frame_Index_39 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382567 CSC_Tcell_01_39 "温度01";
CM_ SG_ 2400382567 CSC_Tcell_02_39 "温度02";
CM_ SG_ 2400382567 CSC_Tcell_03_39 "温度03";
CM_ SG_ 2400382567 CSC_Tcell_04_39 "温度04";
CM_ SG_ 2400382567 CSC_Tcell_05_39 "温度05";
CM_ SG_ 2400382567 CSC_Tcell_06_39 "温度06";
CM_ SG_ 2400382567 CSC_Tcell_07_39 "温度07";
CM_ SG_ 2400382567 CSC_Tcell_08_39 "温度08";
CM_ SG_ 2400382567 CSC_Tcell_09_39 "温度09";
CM_ SG_ 2400382567 CSC_Tcell_10_39 "温度10";
CM_ SG_ 2400382567 CSC_Tcell_11_39 "温度11";
CM_ SG_ 2400382567 CSC_Tcell_12_39 "温度12";
CM_ SG_ 2400382567 CSC_Tcell_13_39 "温度13";
CM_ SG_ 2400382567 CSC_Tcell_14_39 "温度14";
CM_ SG_ 2400382567 CSC_Tcell_15_39 "温度15";
CM_ SG_ 2400382567 CSC_Tcell_16_39 "温度16";
CM_ SG_ 2400382567 CSC_Tcell_17_39 "温度17";
CM_ SG_ 2400382567 CSC_Tcell_18_39 "温度18";
CM_ SG_ 2400382567 CSC_Tcell_19_39 "温度19";
CM_ SG_ 2400382567 CSC_Tcell_20_39 "温度20";
CM_ SG_ 2400382567 CSC_Tcell_21_39 "温度21";
CM_ SG_ 2400382567 CSC_Tcell_22_39 "温度22";
CM_ SG_ 2400382567 CSC_Tcell_23_39 "温度23";
CM_ SG_ 2400382567 CSC_Tcell_24_39 "温度24";
CM_ SG_ 2400382567 CSC_Tcell_25_39 "温度25";
CM_ SG_ 2400382567 CSC_Tcell_26_39 "温度26";
CM_ SG_ 2400382567 CSC_Tcell_27_39 "温度27";
CM_ SG_ 2400382567 CSC_Tcell_28_39 "温度28";
CM_ SG_ 2400382567 CSC_Tcell_29_39 "温度29";
CM_ SG_ 2400382567 CSC_Tcell_30_39 "温度30";
CM_ SG_ 2400382567 CSC_Tcell_31_39 "温度31";
CM_ SG_ 2400382567 CSC_Tcell_32_39 "温度32";
CM_ SG_ 2400382567 CSC_Tcell_33_39 "温度33";
CM_ SG_ 2400382567 CSC_Tcell_34_39 "温度34";
CM_ SG_ 2400382567 CSC_Tcell_35_39 "温度35";
CM_ SG_ 2400382567 CSC_Tcell_36_39 "温度36";
CM_ SG_ 2400382567 CSC_Tcell_37_39 "温度37";
CM_ SG_ 2400382567 CSC_Tcell_38_39 "温度38";
CM_ SG_ 2400382567 CSC_Tcell_39_39 "温度39";
CM_ SG_ 2400382567 CSC_Tcell_40_39 "温度40";
CM_ SG_ 2400382567 CSC_Tcell_41_39 "温度41";
CM_ SG_ 2400382567 CSC_Tcell_42_39 "温度42";
CM_ SG_ 2400382567 CSC_Tcell_43_39 "温度43";
CM_ SG_ 2400382567 CSC_Tcell_44_39 "温度44";
CM_ SG_ 2400382567 CSC_Tcell_45_39 "温度45";
CM_ SG_ 2400382567 CSC_Tcell_46_39 "温度46";
CM_ SG_ 2400382567 CSC_Tcell_47_39 "温度47";
CM_ SG_ 2400382567 CSC_Tcell_48_39 "温度48";
CM_ SG_ 2400382567 CSC_Tcell_49_39 "温度49";
CM_ SG_ 2400382567 CSC_Tcell_50_39 "温度50";
CM_ SG_ 2400382567 CSC_Tcell_51_39 "温度51";
CM_ SG_ 2400382567 CSC_Tcell_52_39 "温度52";
CM_ SG_ 2400382567 CSC_Tcell_53_39 "温度53";
CM_ SG_ 2400382567 CSC_Tcell_54_39 "温度54";
CM_ SG_ 2400382567 CSC_Tcell_55_39 "温度55";
CM_ SG_ 2400382567 CSC_Tcell_56_39 "温度56";
CM_ SG_ 2400382567 CSC_Tcell_57_39 "温度57";
CM_ SG_ 2400382567 CSC_Tcell_58_39 "温度58";
CM_ SG_ 2400382567 CSC_Tcell_59_39 "温度59";
CM_ SG_ 2400382567 CSC_Tcell_60_39 "温度60";
CM_ SG_ 2400382567 CSC_Tcell_61_39 "温度61";
CM_ SG_ 2400382567 CSC_Tcell_62_39 "温度62";
CM_ SG_ 2400382567 CSC_Tcell_63_39 "温度63";
CM_ SG_ 2400382567 CSC_Tcell_64_39 "温度64";
CM_ SG_ 2400382567 CSC_Tcell_65_39 "温度65";
CM_ SG_ 2400382567 CSC_Tcell_66_39 "温度66";
CM_ SG_ 2400382567 CSC_Tcell_67_39 "温度67";
CM_ SG_ 2400382567 CSC_Tcell_68_39 "温度68";
CM_ SG_ 2400382567 CSC_Tcell_69_39 "温度69";
CM_ SG_ 2400382567 CSC_Tcell_70_39 "温度70";
CM_ SG_ 2400382567 CSC_Tcell_71_39 "温度71";
CM_ SG_ 2400382567 CSC_Tcell_72_39 "温度72";
CM_ SG_ 2400382568 CSC_T_No_40 "CSC号";
CM_ SG_ 2400382568 CSC_Tcell_Frame_Index_40 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382568 CSC_Tcell_01_40 "温度01";
CM_ SG_ 2400382568 CSC_Tcell_02_40 "温度02";
CM_ SG_ 2400382568 CSC_Tcell_03_40 "温度03";
CM_ SG_ 2400382568 CSC_Tcell_04_40 "温度04";
CM_ SG_ 2400382568 CSC_Tcell_05_40 "温度05";
CM_ SG_ 2400382568 CSC_Tcell_06_40 "温度06";
CM_ SG_ 2400382568 CSC_Tcell_07_40 "温度07";
CM_ SG_ 2400382568 CSC_Tcell_08_40 "温度08";
CM_ SG_ 2400382568 CSC_Tcell_09_40 "温度09";
CM_ SG_ 2400382568 CSC_Tcell_10_40 "温度10";
CM_ SG_ 2400382568 CSC_Tcell_11_40 "温度11";
CM_ SG_ 2400382568 CSC_Tcell_12_40 "温度12";
CM_ SG_ 2400382568 CSC_Tcell_13_40 "温度13";
CM_ SG_ 2400382568 CSC_Tcell_14_40 "温度14";
CM_ SG_ 2400382568 CSC_Tcell_15_40 "温度15";
CM_ SG_ 2400382568 CSC_Tcell_16_40 "温度16";
CM_ SG_ 2400382568 CSC_Tcell_17_40 "温度17";
CM_ SG_ 2400382568 CSC_Tcell_18_40 "温度18";
CM_ SG_ 2400382568 CSC_Tcell_19_40 "温度19";
CM_ SG_ 2400382568 CSC_Tcell_20_40 "温度20";
CM_ SG_ 2400382568 CSC_Tcell_21_40 "温度21";
CM_ SG_ 2400382568 CSC_Tcell_22_40 "温度22";
CM_ SG_ 2400382568 CSC_Tcell_23_40 "温度23";
CM_ SG_ 2400382568 CSC_Tcell_24_40 "温度24";
CM_ SG_ 2400382568 CSC_Tcell_25_40 "温度25";
CM_ SG_ 2400382568 CSC_Tcell_26_40 "温度26";
CM_ SG_ 2400382568 CSC_Tcell_27_40 "温度27";
CM_ SG_ 2400382568 CSC_Tcell_28_40 "温度28";
CM_ SG_ 2400382568 CSC_Tcell_29_40 "温度29";
CM_ SG_ 2400382568 CSC_Tcell_30_40 "温度30";
CM_ SG_ 2400382568 CSC_Tcell_31_40 "温度31";
CM_ SG_ 2400382568 CSC_Tcell_32_40 "温度32";
CM_ SG_ 2400382568 CSC_Tcell_33_40 "温度33";
CM_ SG_ 2400382568 CSC_Tcell_34_40 "温度34";
CM_ SG_ 2400382568 CSC_Tcell_35_40 "温度35";
CM_ SG_ 2400382568 CSC_Tcell_36_40 "温度36";
CM_ SG_ 2400382568 CSC_Tcell_37_40 "温度37";
CM_ SG_ 2400382568 CSC_Tcell_38_40 "温度38";
CM_ SG_ 2400382568 CSC_Tcell_39_40 "温度39";
CM_ SG_ 2400382568 CSC_Tcell_40_40 "温度40";
CM_ SG_ 2400382568 CSC_Tcell_41_40 "温度41";
CM_ SG_ 2400382568 CSC_Tcell_42_40 "温度42";
CM_ SG_ 2400382568 CSC_Tcell_43_40 "温度43";
CM_ SG_ 2400382568 CSC_Tcell_44_40 "温度44";
CM_ SG_ 2400382568 CSC_Tcell_45_40 "温度45";
CM_ SG_ 2400382568 CSC_Tcell_46_40 "温度46";
CM_ SG_ 2400382568 CSC_Tcell_47_40 "温度47";
CM_ SG_ 2400382568 CSC_Tcell_48_40 "温度48";
CM_ SG_ 2400382568 CSC_Tcell_49_40 "温度49";
CM_ SG_ 2400382568 CSC_Tcell_50_40 "温度50";
CM_ SG_ 2400382568 CSC_Tcell_51_40 "温度51";
CM_ SG_ 2400382568 CSC_Tcell_52_40 "温度52";
CM_ SG_ 2400382568 CSC_Tcell_53_40 "温度53";
CM_ SG_ 2400382568 CSC_Tcell_54_40 "温度54";
CM_ SG_ 2400382568 CSC_Tcell_55_40 "温度55";
CM_ SG_ 2400382568 CSC_Tcell_56_40 "温度56";
CM_ SG_ 2400382568 CSC_Tcell_57_40 "温度57";
CM_ SG_ 2400382568 CSC_Tcell_58_40 "温度58";
CM_ SG_ 2400382568 CSC_Tcell_59_40 "温度59";
CM_ SG_ 2400382568 CSC_Tcell_60_40 "温度60";
CM_ SG_ 2400382568 CSC_Tcell_61_40 "温度61";
CM_ SG_ 2400382568 CSC_Tcell_62_40 "温度62";
CM_ SG_ 2400382568 CSC_Tcell_63_40 "温度63";
CM_ SG_ 2400382568 CSC_Tcell_64_40 "温度64";
CM_ SG_ 2400382568 CSC_Tcell_65_40 "温度65";
CM_ SG_ 2400382568 CSC_Tcell_66_40 "温度66";
CM_ SG_ 2400382568 CSC_Tcell_67_40 "温度67";
CM_ SG_ 2400382568 CSC_Tcell_68_40 "温度68";
CM_ SG_ 2400382568 CSC_Tcell_69_40 "温度69";
CM_ SG_ 2400382568 CSC_Tcell_70_40 "温度70";
CM_ SG_ 2400382568 CSC_Tcell_71_40 "温度71";
CM_ SG_ 2400382568 CSC_Tcell_72_40 "温度72";
CM_ SG_ 2400382569 CSC_T_No_41 "CSC号";
CM_ SG_ 2400382569 CSC_Tcell_Frame_Index_41 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382569 CSC_Tcell_01_41 "温度01";
CM_ SG_ 2400382569 CSC_Tcell_02_41 "温度02";
CM_ SG_ 2400382569 CSC_Tcell_03_41 "温度03";
CM_ SG_ 2400382569 CSC_Tcell_04_41 "温度04";
CM_ SG_ 2400382569 CSC_Tcell_05_41 "温度05";
CM_ SG_ 2400382569 CSC_Tcell_06_41 "温度06";
CM_ SG_ 2400382569 CSC_Tcell_07_41 "温度07";
CM_ SG_ 2400382569 CSC_Tcell_08_41 "温度08";
CM_ SG_ 2400382569 CSC_Tcell_09_41 "温度09";
CM_ SG_ 2400382569 CSC_Tcell_10_41 "温度10";
CM_ SG_ 2400382569 CSC_Tcell_11_41 "温度11";
CM_ SG_ 2400382569 CSC_Tcell_12_41 "温度12";
CM_ SG_ 2400382569 CSC_Tcell_13_41 "温度13";
CM_ SG_ 2400382569 CSC_Tcell_14_41 "温度14";
CM_ SG_ 2400382569 CSC_Tcell_15_41 "温度15";
CM_ SG_ 2400382569 CSC_Tcell_16_41 "温度16";
CM_ SG_ 2400382569 CSC_Tcell_17_41 "温度17";
CM_ SG_ 2400382569 CSC_Tcell_18_41 "温度18";
CM_ SG_ 2400382569 CSC_Tcell_19_41 "温度19";
CM_ SG_ 2400382569 CSC_Tcell_20_41 "温度20";
CM_ SG_ 2400382569 CSC_Tcell_21_41 "温度21";
CM_ SG_ 2400382569 CSC_Tcell_22_41 "温度22";
CM_ SG_ 2400382569 CSC_Tcell_23_41 "温度23";
CM_ SG_ 2400382569 CSC_Tcell_24_41 "温度24";
CM_ SG_ 2400382569 CSC_Tcell_25_41 "温度25";
CM_ SG_ 2400382569 CSC_Tcell_26_41 "温度26";
CM_ SG_ 2400382569 CSC_Tcell_27_41 "温度27";
CM_ SG_ 2400382569 CSC_Tcell_28_41 "温度28";
CM_ SG_ 2400382569 CSC_Tcell_29_41 "温度29";
CM_ SG_ 2400382569 CSC_Tcell_30_41 "温度30";
CM_ SG_ 2400382569 CSC_Tcell_31_41 "温度31";
CM_ SG_ 2400382569 CSC_Tcell_32_41 "温度32";
CM_ SG_ 2400382569 CSC_Tcell_33_41 "温度33";
CM_ SG_ 2400382569 CSC_Tcell_34_41 "温度34";
CM_ SG_ 2400382569 CSC_Tcell_35_41 "温度35";
CM_ SG_ 2400382569 CSC_Tcell_36_41 "温度36";
CM_ SG_ 2400382569 CSC_Tcell_37_41 "温度37";
CM_ SG_ 2400382569 CSC_Tcell_38_41 "温度38";
CM_ SG_ 2400382569 CSC_Tcell_39_41 "温度39";
CM_ SG_ 2400382569 CSC_Tcell_40_41 "温度40";
CM_ SG_ 2400382569 CSC_Tcell_41_41 "温度41";
CM_ SG_ 2400382569 CSC_Tcell_42_41 "温度42";
CM_ SG_ 2400382569 CSC_Tcell_43_41 "温度43";
CM_ SG_ 2400382569 CSC_Tcell_44_41 "温度44";
CM_ SG_ 2400382569 CSC_Tcell_45_41 "温度45";
CM_ SG_ 2400382569 CSC_Tcell_46_41 "温度46";
CM_ SG_ 2400382569 CSC_Tcell_47_41 "温度47";
CM_ SG_ 2400382569 CSC_Tcell_48_41 "温度48";
CM_ SG_ 2400382569 CSC_Tcell_49_41 "温度49";
CM_ SG_ 2400382569 CSC_Tcell_50_41 "温度50";
CM_ SG_ 2400382569 CSC_Tcell_51_41 "温度51";
CM_ SG_ 2400382569 CSC_Tcell_52_41 "温度52";
CM_ SG_ 2400382569 CSC_Tcell_53_41 "温度53";
CM_ SG_ 2400382569 CSC_Tcell_54_41 "温度54";
CM_ SG_ 2400382569 CSC_Tcell_55_41 "温度55";
CM_ SG_ 2400382569 CSC_Tcell_56_41 "温度56";
CM_ SG_ 2400382569 CSC_Tcell_57_41 "温度57";
CM_ SG_ 2400382569 CSC_Tcell_58_41 "温度58";
CM_ SG_ 2400382569 CSC_Tcell_59_41 "温度59";
CM_ SG_ 2400382569 CSC_Tcell_60_41 "温度60";
CM_ SG_ 2400382569 CSC_Tcell_61_41 "温度61";
CM_ SG_ 2400382569 CSC_Tcell_62_41 "温度62";
CM_ SG_ 2400382569 CSC_Tcell_63_41 "温度63";
CM_ SG_ 2400382569 CSC_Tcell_64_41 "温度64";
CM_ SG_ 2400382569 CSC_Tcell_65_41 "温度65";
CM_ SG_ 2400382569 CSC_Tcell_66_41 "温度66";
CM_ SG_ 2400382569 CSC_Tcell_67_41 "温度67";
CM_ SG_ 2400382569 CSC_Tcell_68_41 "温度68";
CM_ SG_ 2400382569 CSC_Tcell_69_41 "温度69";
CM_ SG_ 2400382569 CSC_Tcell_70_41 "温度70";
CM_ SG_ 2400382569 CSC_Tcell_71_41 "温度71";
CM_ SG_ 2400382569 CSC_Tcell_72_41 "温度72";
CM_ SG_ 2400382570 CSC_T_No_42 "CSC号";
CM_ SG_ 2400382570 CSC_Tcell_Frame_Index_42 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382570 CSC_Tcell_01_42 "温度01";
CM_ SG_ 2400382570 CSC_Tcell_02_42 "温度02";
CM_ SG_ 2400382570 CSC_Tcell_03_42 "温度03";
CM_ SG_ 2400382570 CSC_Tcell_04_42 "温度04";
CM_ SG_ 2400382570 CSC_Tcell_05_42 "温度05";
CM_ SG_ 2400382570 CSC_Tcell_06_42 "温度06";
CM_ SG_ 2400382570 CSC_Tcell_07_42 "温度07";
CM_ SG_ 2400382570 CSC_Tcell_08_42 "温度08";
CM_ SG_ 2400382570 CSC_Tcell_09_42 "温度09";
CM_ SG_ 2400382570 CSC_Tcell_10_42 "温度10";
CM_ SG_ 2400382570 CSC_Tcell_11_42 "温度11";
CM_ SG_ 2400382570 CSC_Tcell_12_42 "温度12";
CM_ SG_ 2400382570 CSC_Tcell_13_42 "温度13";
CM_ SG_ 2400382570 CSC_Tcell_14_42 "温度14";
CM_ SG_ 2400382570 CSC_Tcell_15_42 "温度15";
CM_ SG_ 2400382570 CSC_Tcell_16_42 "温度16";
CM_ SG_ 2400382570 CSC_Tcell_17_42 "温度17";
CM_ SG_ 2400382570 CSC_Tcell_18_42 "温度18";
CM_ SG_ 2400382570 CSC_Tcell_19_42 "温度19";
CM_ SG_ 2400382570 CSC_Tcell_20_42 "温度20";
CM_ SG_ 2400382570 CSC_Tcell_21_42 "温度21";
CM_ SG_ 2400382570 CSC_Tcell_22_42 "温度22";
CM_ SG_ 2400382570 CSC_Tcell_23_42 "温度23";
CM_ SG_ 2400382570 CSC_Tcell_24_42 "温度24";
CM_ SG_ 2400382570 CSC_Tcell_25_42 "温度25";
CM_ SG_ 2400382570 CSC_Tcell_26_42 "温度26";
CM_ SG_ 2400382570 CSC_Tcell_27_42 "温度27";
CM_ SG_ 2400382570 CSC_Tcell_28_42 "温度28";
CM_ SG_ 2400382570 CSC_Tcell_29_42 "温度29";
CM_ SG_ 2400382570 CSC_Tcell_30_42 "温度30";
CM_ SG_ 2400382570 CSC_Tcell_31_42 "温度31";
CM_ SG_ 2400382570 CSC_Tcell_32_42 "温度32";
CM_ SG_ 2400382570 CSC_Tcell_33_42 "温度33";
CM_ SG_ 2400382570 CSC_Tcell_34_42 "温度34";
CM_ SG_ 2400382570 CSC_Tcell_35_42 "温度35";
CM_ SG_ 2400382570 CSC_Tcell_36_42 "温度36";
CM_ SG_ 2400382570 CSC_Tcell_37_42 "温度37";
CM_ SG_ 2400382570 CSC_Tcell_38_42 "温度38";
CM_ SG_ 2400382570 CSC_Tcell_39_42 "温度39";
CM_ SG_ 2400382570 CSC_Tcell_40_42 "温度40";
CM_ SG_ 2400382570 CSC_Tcell_41_42 "温度41";
CM_ SG_ 2400382570 CSC_Tcell_42_42 "温度42";
CM_ SG_ 2400382570 CSC_Tcell_43_42 "温度43";
CM_ SG_ 2400382570 CSC_Tcell_44_42 "温度44";
CM_ SG_ 2400382570 CSC_Tcell_45_42 "温度45";
CM_ SG_ 2400382570 CSC_Tcell_46_42 "温度46";
CM_ SG_ 2400382570 CSC_Tcell_47_42 "温度47";
CM_ SG_ 2400382570 CSC_Tcell_48_42 "温度48";
CM_ SG_ 2400382570 CSC_Tcell_49_42 "温度49";
CM_ SG_ 2400382570 CSC_Tcell_50_42 "温度50";
CM_ SG_ 2400382570 CSC_Tcell_51_42 "温度51";
CM_ SG_ 2400382570 CSC_Tcell_52_42 "温度52";
CM_ SG_ 2400382570 CSC_Tcell_53_42 "温度53";
CM_ SG_ 2400382570 CSC_Tcell_54_42 "温度54";
CM_ SG_ 2400382570 CSC_Tcell_55_42 "温度55";
CM_ SG_ 2400382570 CSC_Tcell_56_42 "温度56";
CM_ SG_ 2400382570 CSC_Tcell_57_42 "温度57";
CM_ SG_ 2400382570 CSC_Tcell_58_42 "温度58";
CM_ SG_ 2400382570 CSC_Tcell_59_42 "温度59";
CM_ SG_ 2400382570 CSC_Tcell_60_42 "温度60";
CM_ SG_ 2400382570 CSC_Tcell_61_42 "温度61";
CM_ SG_ 2400382570 CSC_Tcell_62_42 "温度62";
CM_ SG_ 2400382570 CSC_Tcell_63_42 "温度63";
CM_ SG_ 2400382570 CSC_Tcell_64_42 "温度64";
CM_ SG_ 2400382570 CSC_Tcell_65_42 "温度65";
CM_ SG_ 2400382570 CSC_Tcell_66_42 "温度66";
CM_ SG_ 2400382570 CSC_Tcell_67_42 "温度67";
CM_ SG_ 2400382570 CSC_Tcell_68_42 "温度68";
CM_ SG_ 2400382570 CSC_Tcell_69_42 "温度69";
CM_ SG_ 2400382570 CSC_Tcell_70_42 "温度70";
CM_ SG_ 2400382570 CSC_Tcell_71_42 "温度71";
CM_ SG_ 2400382570 CSC_Tcell_72_42 "温度72";
CM_ SG_ 2400382571 CSC_T_No_43 "CSC号";
CM_ SG_ 2400382571 CSC_Tcell_Frame_Index_43 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382571 CSC_Tcell_01_43 "温度01";
CM_ SG_ 2400382571 CSC_Tcell_02_43 "温度02";
CM_ SG_ 2400382571 CSC_Tcell_03_43 "温度03";
CM_ SG_ 2400382571 CSC_Tcell_04_43 "温度04";
CM_ SG_ 2400382571 CSC_Tcell_05_43 "温度05";
CM_ SG_ 2400382571 CSC_Tcell_06_43 "温度06";
CM_ SG_ 2400382571 CSC_Tcell_07_43 "温度07";
CM_ SG_ 2400382571 CSC_Tcell_08_43 "温度08";
CM_ SG_ 2400382571 CSC_Tcell_09_43 "温度09";
CM_ SG_ 2400382571 CSC_Tcell_10_43 "温度10";
CM_ SG_ 2400382571 CSC_Tcell_11_43 "温度11";
CM_ SG_ 2400382571 CSC_Tcell_12_43 "温度12";
CM_ SG_ 2400382571 CSC_Tcell_13_43 "温度13";
CM_ SG_ 2400382571 CSC_Tcell_14_43 "温度14";
CM_ SG_ 2400382571 CSC_Tcell_15_43 "温度15";
CM_ SG_ 2400382571 CSC_Tcell_16_43 "温度16";
CM_ SG_ 2400382571 CSC_Tcell_17_43 "温度17";
CM_ SG_ 2400382571 CSC_Tcell_18_43 "温度18";
CM_ SG_ 2400382571 CSC_Tcell_19_43 "温度19";
CM_ SG_ 2400382571 CSC_Tcell_20_43 "温度20";
CM_ SG_ 2400382571 CSC_Tcell_21_43 "温度21";
CM_ SG_ 2400382571 CSC_Tcell_22_43 "温度22";
CM_ SG_ 2400382571 CSC_Tcell_23_43 "温度23";
CM_ SG_ 2400382571 CSC_Tcell_24_43 "温度24";
CM_ SG_ 2400382571 CSC_Tcell_25_43 "温度25";
CM_ SG_ 2400382571 CSC_Tcell_26_43 "温度26";
CM_ SG_ 2400382571 CSC_Tcell_27_43 "温度27";
CM_ SG_ 2400382571 CSC_Tcell_28_43 "温度28";
CM_ SG_ 2400382571 CSC_Tcell_29_43 "温度29";
CM_ SG_ 2400382571 CSC_Tcell_30_43 "温度30";
CM_ SG_ 2400382571 CSC_Tcell_31_43 "温度31";
CM_ SG_ 2400382571 CSC_Tcell_32_43 "温度32";
CM_ SG_ 2400382571 CSC_Tcell_33_43 "温度33";
CM_ SG_ 2400382571 CSC_Tcell_34_43 "温度34";
CM_ SG_ 2400382571 CSC_Tcell_35_43 "温度35";
CM_ SG_ 2400382571 CSC_Tcell_36_43 "温度36";
CM_ SG_ 2400382571 CSC_Tcell_37_43 "温度37";
CM_ SG_ 2400382571 CSC_Tcell_38_43 "温度38";
CM_ SG_ 2400382571 CSC_Tcell_39_43 "温度39";
CM_ SG_ 2400382571 CSC_Tcell_40_43 "温度40";
CM_ SG_ 2400382571 CSC_Tcell_41_43 "温度41";
CM_ SG_ 2400382571 CSC_Tcell_42_43 "温度42";
CM_ SG_ 2400382571 CSC_Tcell_43_43 "温度43";
CM_ SG_ 2400382571 CSC_Tcell_44_43 "温度44";
CM_ SG_ 2400382571 CSC_Tcell_45_43 "温度45";
CM_ SG_ 2400382571 CSC_Tcell_46_43 "温度46";
CM_ SG_ 2400382571 CSC_Tcell_47_43 "温度47";
CM_ SG_ 2400382571 CSC_Tcell_48_43 "温度48";
CM_ SG_ 2400382571 CSC_Tcell_49_43 "温度49";
CM_ SG_ 2400382571 CSC_Tcell_50_43 "温度50";
CM_ SG_ 2400382571 CSC_Tcell_51_43 "温度51";
CM_ SG_ 2400382571 CSC_Tcell_52_43 "温度52";
CM_ SG_ 2400382571 CSC_Tcell_53_43 "温度53";
CM_ SG_ 2400382571 CSC_Tcell_54_43 "温度54";
CM_ SG_ 2400382571 CSC_Tcell_55_43 "温度55";
CM_ SG_ 2400382571 CSC_Tcell_56_43 "温度56";
CM_ SG_ 2400382571 CSC_Tcell_57_43 "温度57";
CM_ SG_ 2400382571 CSC_Tcell_58_43 "温度58";
CM_ SG_ 2400382571 CSC_Tcell_59_43 "温度59";
CM_ SG_ 2400382571 CSC_Tcell_60_43 "温度60";
CM_ SG_ 2400382571 CSC_Tcell_61_43 "温度61";
CM_ SG_ 2400382571 CSC_Tcell_62_43 "温度62";
CM_ SG_ 2400382571 CSC_Tcell_63_43 "温度63";
CM_ SG_ 2400382571 CSC_Tcell_64_43 "温度64";
CM_ SG_ 2400382571 CSC_Tcell_65_43 "温度65";
CM_ SG_ 2400382571 CSC_Tcell_66_43 "温度66";
CM_ SG_ 2400382571 CSC_Tcell_67_43 "温度67";
CM_ SG_ 2400382571 CSC_Tcell_68_43 "温度68";
CM_ SG_ 2400382571 CSC_Tcell_69_43 "温度69";
CM_ SG_ 2400382571 CSC_Tcell_70_43 "温度70";
CM_ SG_ 2400382571 CSC_Tcell_71_43 "温度71";
CM_ SG_ 2400382571 CSC_Tcell_72_43 "温度72";
CM_ SG_ 2400382572 CSC_T_No_44 "CSC号";
CM_ SG_ 2400382572 CSC_Tcell_Frame_Index_44 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382572 CSC_Tcell_01_44 "温度01";
CM_ SG_ 2400382572 CSC_Tcell_02_44 "温度02";
CM_ SG_ 2400382572 CSC_Tcell_03_44 "温度03";
CM_ SG_ 2400382572 CSC_Tcell_04_44 "温度04";
CM_ SG_ 2400382572 CSC_Tcell_05_44 "温度05";
CM_ SG_ 2400382572 CSC_Tcell_06_44 "温度06";
CM_ SG_ 2400382572 CSC_Tcell_07_44 "温度07";
CM_ SG_ 2400382572 CSC_Tcell_08_44 "温度08";
CM_ SG_ 2400382572 CSC_Tcell_09_44 "温度09";
CM_ SG_ 2400382572 CSC_Tcell_10_44 "温度10";
CM_ SG_ 2400382572 CSC_Tcell_11_44 "温度11";
CM_ SG_ 2400382572 CSC_Tcell_12_44 "温度12";
CM_ SG_ 2400382572 CSC_Tcell_13_44 "温度13";
CM_ SG_ 2400382572 CSC_Tcell_14_44 "温度14";
CM_ SG_ 2400382572 CSC_Tcell_15_44 "温度15";
CM_ SG_ 2400382572 CSC_Tcell_16_44 "温度16";
CM_ SG_ 2400382572 CSC_Tcell_17_44 "温度17";
CM_ SG_ 2400382572 CSC_Tcell_18_44 "温度18";
CM_ SG_ 2400382572 CSC_Tcell_19_44 "温度19";
CM_ SG_ 2400382572 CSC_Tcell_20_44 "温度20";
CM_ SG_ 2400382572 CSC_Tcell_21_44 "温度21";
CM_ SG_ 2400382572 CSC_Tcell_22_44 "温度22";
CM_ SG_ 2400382572 CSC_Tcell_23_44 "温度23";
CM_ SG_ 2400382572 CSC_Tcell_24_44 "温度24";
CM_ SG_ 2400382572 CSC_Tcell_25_44 "温度25";
CM_ SG_ 2400382572 CSC_Tcell_26_44 "温度26";
CM_ SG_ 2400382572 CSC_Tcell_27_44 "温度27";
CM_ SG_ 2400382572 CSC_Tcell_28_44 "温度28";
CM_ SG_ 2400382572 CSC_Tcell_29_44 "温度29";
CM_ SG_ 2400382572 CSC_Tcell_30_44 "温度30";
CM_ SG_ 2400382572 CSC_Tcell_31_44 "温度31";
CM_ SG_ 2400382572 CSC_Tcell_32_44 "温度32";
CM_ SG_ 2400382572 CSC_Tcell_33_44 "温度33";
CM_ SG_ 2400382572 CSC_Tcell_34_44 "温度34";
CM_ SG_ 2400382572 CSC_Tcell_35_44 "温度35";
CM_ SG_ 2400382572 CSC_Tcell_36_44 "温度36";
CM_ SG_ 2400382572 CSC_Tcell_37_44 "温度37";
CM_ SG_ 2400382572 CSC_Tcell_38_44 "温度38";
CM_ SG_ 2400382572 CSC_Tcell_39_44 "温度39";
CM_ SG_ 2400382572 CSC_Tcell_40_44 "温度40";
CM_ SG_ 2400382572 CSC_Tcell_41_44 "温度41";
CM_ SG_ 2400382572 CSC_Tcell_42_44 "温度42";
CM_ SG_ 2400382572 CSC_Tcell_43_44 "温度43";
CM_ SG_ 2400382572 CSC_Tcell_44_44 "温度44";
CM_ SG_ 2400382572 CSC_Tcell_45_44 "温度45";
CM_ SG_ 2400382572 CSC_Tcell_46_44 "温度46";
CM_ SG_ 2400382572 CSC_Tcell_47_44 "温度47";
CM_ SG_ 2400382572 CSC_Tcell_48_44 "温度48";
CM_ SG_ 2400382572 CSC_Tcell_49_44 "温度49";
CM_ SG_ 2400382572 CSC_Tcell_50_44 "温度50";
CM_ SG_ 2400382572 CSC_Tcell_51_44 "温度51";
CM_ SG_ 2400382572 CSC_Tcell_52_44 "温度52";
CM_ SG_ 2400382572 CSC_Tcell_53_44 "温度53";
CM_ SG_ 2400382572 CSC_Tcell_54_44 "温度54";
CM_ SG_ 2400382572 CSC_Tcell_55_44 "温度55";
CM_ SG_ 2400382572 CSC_Tcell_56_44 "温度56";
CM_ SG_ 2400382572 CSC_Tcell_57_44 "温度57";
CM_ SG_ 2400382572 CSC_Tcell_58_44 "温度58";
CM_ SG_ 2400382572 CSC_Tcell_59_44 "温度59";
CM_ SG_ 2400382572 CSC_Tcell_60_44 "温度60";
CM_ SG_ 2400382572 CSC_Tcell_61_44 "温度61";
CM_ SG_ 2400382572 CSC_Tcell_62_44 "温度62";
CM_ SG_ 2400382572 CSC_Tcell_63_44 "温度63";
CM_ SG_ 2400382572 CSC_Tcell_64_44 "温度64";
CM_ SG_ 2400382572 CSC_Tcell_65_44 "温度65";
CM_ SG_ 2400382572 CSC_Tcell_66_44 "温度66";
CM_ SG_ 2400382572 CSC_Tcell_67_44 "温度67";
CM_ SG_ 2400382572 CSC_Tcell_68_44 "温度68";
CM_ SG_ 2400382572 CSC_Tcell_69_44 "温度69";
CM_ SG_ 2400382572 CSC_Tcell_70_44 "温度70";
CM_ SG_ 2400382572 CSC_Tcell_71_44 "温度71";
CM_ SG_ 2400382572 CSC_Tcell_72_44 "温度72";
CM_ SG_ 2400382573 CSC_T_No_45 "CSC号";
CM_ SG_ 2400382573 CSC_Tcell_Frame_Index_45 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382573 CSC_Tcell_01_45 "温度01";
CM_ SG_ 2400382573 CSC_Tcell_02_45 "温度02";
CM_ SG_ 2400382573 CSC_Tcell_03_45 "温度03";
CM_ SG_ 2400382573 CSC_Tcell_04_45 "温度04";
CM_ SG_ 2400382573 CSC_Tcell_05_45 "温度05";
CM_ SG_ 2400382573 CSC_Tcell_06_45 "温度06";
CM_ SG_ 2400382573 CSC_Tcell_07_45 "温度07";
CM_ SG_ 2400382573 CSC_Tcell_08_45 "温度08";
CM_ SG_ 2400382573 CSC_Tcell_09_45 "温度09";
CM_ SG_ 2400382573 CSC_Tcell_10_45 "温度10";
CM_ SG_ 2400382573 CSC_Tcell_11_45 "温度11";
CM_ SG_ 2400382573 CSC_Tcell_12_45 "温度12";
CM_ SG_ 2400382573 CSC_Tcell_13_45 "温度13";
CM_ SG_ 2400382573 CSC_Tcell_14_45 "温度14";
CM_ SG_ 2400382573 CSC_Tcell_15_45 "温度15";
CM_ SG_ 2400382573 CSC_Tcell_16_45 "温度16";
CM_ SG_ 2400382573 CSC_Tcell_17_45 "温度17";
CM_ SG_ 2400382573 CSC_Tcell_18_45 "温度18";
CM_ SG_ 2400382573 CSC_Tcell_19_45 "温度19";
CM_ SG_ 2400382573 CSC_Tcell_20_45 "温度20";
CM_ SG_ 2400382573 CSC_Tcell_21_45 "温度21";
CM_ SG_ 2400382573 CSC_Tcell_22_45 "温度22";
CM_ SG_ 2400382573 CSC_Tcell_23_45 "温度23";
CM_ SG_ 2400382573 CSC_Tcell_24_45 "温度24";
CM_ SG_ 2400382573 CSC_Tcell_25_45 "温度25";
CM_ SG_ 2400382573 CSC_Tcell_26_45 "温度26";
CM_ SG_ 2400382573 CSC_Tcell_27_45 "温度27";
CM_ SG_ 2400382573 CSC_Tcell_28_45 "温度28";
CM_ SG_ 2400382573 CSC_Tcell_29_45 "温度29";
CM_ SG_ 2400382573 CSC_Tcell_30_45 "温度30";
CM_ SG_ 2400382573 CSC_Tcell_31_45 "温度31";
CM_ SG_ 2400382573 CSC_Tcell_32_45 "温度32";
CM_ SG_ 2400382573 CSC_Tcell_33_45 "温度33";
CM_ SG_ 2400382573 CSC_Tcell_34_45 "温度34";
CM_ SG_ 2400382573 CSC_Tcell_35_45 "温度35";
CM_ SG_ 2400382573 CSC_Tcell_36_45 "温度36";
CM_ SG_ 2400382573 CSC_Tcell_37_45 "温度37";
CM_ SG_ 2400382573 CSC_Tcell_38_45 "温度38";
CM_ SG_ 2400382573 CSC_Tcell_39_45 "温度39";
CM_ SG_ 2400382573 CSC_Tcell_40_45 "温度40";
CM_ SG_ 2400382573 CSC_Tcell_41_45 "温度41";
CM_ SG_ 2400382573 CSC_Tcell_42_45 "温度42";
CM_ SG_ 2400382573 CSC_Tcell_43_45 "温度43";
CM_ SG_ 2400382573 CSC_Tcell_44_45 "温度44";
CM_ SG_ 2400382573 CSC_Tcell_45_45 "温度45";
CM_ SG_ 2400382573 CSC_Tcell_46_45 "温度46";
CM_ SG_ 2400382573 CSC_Tcell_47_45 "温度47";
CM_ SG_ 2400382573 CSC_Tcell_48_45 "温度48";
CM_ SG_ 2400382573 CSC_Tcell_49_45 "温度49";
CM_ SG_ 2400382573 CSC_Tcell_50_45 "温度50";
CM_ SG_ 2400382573 CSC_Tcell_51_45 "温度51";
CM_ SG_ 2400382573 CSC_Tcell_52_45 "温度52";
CM_ SG_ 2400382573 CSC_Tcell_53_45 "温度53";
CM_ SG_ 2400382573 CSC_Tcell_54_45 "温度54";
CM_ SG_ 2400382573 CSC_Tcell_55_45 "温度55";
CM_ SG_ 2400382573 CSC_Tcell_56_45 "温度56";
CM_ SG_ 2400382573 CSC_Tcell_57_45 "温度57";
CM_ SG_ 2400382573 CSC_Tcell_58_45 "温度58";
CM_ SG_ 2400382573 CSC_Tcell_59_45 "温度59";
CM_ SG_ 2400382573 CSC_Tcell_60_45 "温度60";
CM_ SG_ 2400382573 CSC_Tcell_61_45 "温度61";
CM_ SG_ 2400382573 CSC_Tcell_62_45 "温度62";
CM_ SG_ 2400382573 CSC_Tcell_63_45 "温度63";
CM_ SG_ 2400382573 CSC_Tcell_64_45 "温度64";
CM_ SG_ 2400382573 CSC_Tcell_65_45 "温度65";
CM_ SG_ 2400382573 CSC_Tcell_66_45 "温度66";
CM_ SG_ 2400382573 CSC_Tcell_67_45 "温度67";
CM_ SG_ 2400382573 CSC_Tcell_68_45 "温度68";
CM_ SG_ 2400382573 CSC_Tcell_69_45 "温度69";
CM_ SG_ 2400382573 CSC_Tcell_70_45 "温度70";
CM_ SG_ 2400382573 CSC_Tcell_71_45 "温度71";
CM_ SG_ 2400382573 CSC_Tcell_72_45 "温度72";
CM_ SG_ 2400382574 CSC_T_No_46 "CSC号";
CM_ SG_ 2400382574 CSC_Tcell_Frame_Index_46 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382574 CSC_Tcell_01_46 "温度01";
CM_ SG_ 2400382574 CSC_Tcell_02_46 "温度02";
CM_ SG_ 2400382574 CSC_Tcell_03_46 "温度03";
CM_ SG_ 2400382574 CSC_Tcell_04_46 "温度04";
CM_ SG_ 2400382574 CSC_Tcell_05_46 "温度05";
CM_ SG_ 2400382574 CSC_Tcell_06_46 "温度06";
CM_ SG_ 2400382574 CSC_Tcell_07_46 "温度07";
CM_ SG_ 2400382574 CSC_Tcell_08_46 "温度08";
CM_ SG_ 2400382574 CSC_Tcell_09_46 "温度09";
CM_ SG_ 2400382574 CSC_Tcell_10_46 "温度10";
CM_ SG_ 2400382574 CSC_Tcell_11_46 "温度11";
CM_ SG_ 2400382574 CSC_Tcell_12_46 "温度12";
CM_ SG_ 2400382574 CSC_Tcell_13_46 "温度13";
CM_ SG_ 2400382574 CSC_Tcell_14_46 "温度14";
CM_ SG_ 2400382574 CSC_Tcell_15_46 "温度15";
CM_ SG_ 2400382574 CSC_Tcell_16_46 "温度16";
CM_ SG_ 2400382574 CSC_Tcell_17_46 "温度17";
CM_ SG_ 2400382574 CSC_Tcell_18_46 "温度18";
CM_ SG_ 2400382574 CSC_Tcell_19_46 "温度19";
CM_ SG_ 2400382574 CSC_Tcell_20_46 "温度20";
CM_ SG_ 2400382574 CSC_Tcell_21_46 "温度21";
CM_ SG_ 2400382574 CSC_Tcell_22_46 "温度22";
CM_ SG_ 2400382574 CSC_Tcell_23_46 "温度23";
CM_ SG_ 2400382574 CSC_Tcell_24_46 "温度24";
CM_ SG_ 2400382574 CSC_Tcell_25_46 "温度25";
CM_ SG_ 2400382574 CSC_Tcell_26_46 "温度26";
CM_ SG_ 2400382574 CSC_Tcell_27_46 "温度27";
CM_ SG_ 2400382574 CSC_Tcell_28_46 "温度28";
CM_ SG_ 2400382574 CSC_Tcell_29_46 "温度29";
CM_ SG_ 2400382574 CSC_Tcell_30_46 "温度30";
CM_ SG_ 2400382574 CSC_Tcell_31_46 "温度31";
CM_ SG_ 2400382574 CSC_Tcell_32_46 "温度32";
CM_ SG_ 2400382574 CSC_Tcell_33_46 "温度33";
CM_ SG_ 2400382574 CSC_Tcell_34_46 "温度34";
CM_ SG_ 2400382574 CSC_Tcell_35_46 "温度35";
CM_ SG_ 2400382574 CSC_Tcell_36_46 "温度36";
CM_ SG_ 2400382574 CSC_Tcell_37_46 "温度37";
CM_ SG_ 2400382574 CSC_Tcell_38_46 "温度38";
CM_ SG_ 2400382574 CSC_Tcell_39_46 "温度39";
CM_ SG_ 2400382574 CSC_Tcell_40_46 "温度40";
CM_ SG_ 2400382574 CSC_Tcell_41_46 "温度41";
CM_ SG_ 2400382574 CSC_Tcell_42_46 "温度42";
CM_ SG_ 2400382574 CSC_Tcell_43_46 "温度43";
CM_ SG_ 2400382574 CSC_Tcell_44_46 "温度44";
CM_ SG_ 2400382574 CSC_Tcell_45_46 "温度45";
CM_ SG_ 2400382574 CSC_Tcell_46_46 "温度46";
CM_ SG_ 2400382574 CSC_Tcell_47_46 "温度47";
CM_ SG_ 2400382574 CSC_Tcell_48_46 "温度48";
CM_ SG_ 2400382574 CSC_Tcell_49_46 "温度49";
CM_ SG_ 2400382574 CSC_Tcell_50_46 "温度50";
CM_ SG_ 2400382574 CSC_Tcell_51_46 "温度51";
CM_ SG_ 2400382574 CSC_Tcell_52_46 "温度52";
CM_ SG_ 2400382574 CSC_Tcell_53_46 "温度53";
CM_ SG_ 2400382574 CSC_Tcell_54_46 "温度54";
CM_ SG_ 2400382574 CSC_Tcell_55_46 "温度55";
CM_ SG_ 2400382574 CSC_Tcell_56_46 "温度56";
CM_ SG_ 2400382574 CSC_Tcell_57_46 "温度57";
CM_ SG_ 2400382574 CSC_Tcell_58_46 "温度58";
CM_ SG_ 2400382574 CSC_Tcell_59_46 "温度59";
CM_ SG_ 2400382574 CSC_Tcell_60_46 "温度60";
CM_ SG_ 2400382574 CSC_Tcell_61_46 "温度61";
CM_ SG_ 2400382574 CSC_Tcell_62_46 "温度62";
CM_ SG_ 2400382574 CSC_Tcell_63_46 "温度63";
CM_ SG_ 2400382574 CSC_Tcell_64_46 "温度64";
CM_ SG_ 2400382574 CSC_Tcell_65_46 "温度65";
CM_ SG_ 2400382574 CSC_Tcell_66_46 "温度66";
CM_ SG_ 2400382574 CSC_Tcell_67_46 "温度67";
CM_ SG_ 2400382574 CSC_Tcell_68_46 "温度68";
CM_ SG_ 2400382574 CSC_Tcell_69_46 "温度69";
CM_ SG_ 2400382574 CSC_Tcell_70_46 "温度70";
CM_ SG_ 2400382574 CSC_Tcell_71_46 "温度71";
CM_ SG_ 2400382574 CSC_Tcell_72_46 "温度72";
CM_ SG_ 2400382575 CSC_T_No_47 "CSC号";
CM_ SG_ 2400382575 CSC_Tcell_Frame_Index_47 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382575 CSC_Tcell_01_47 "温度01";
CM_ SG_ 2400382575 CSC_Tcell_02_47 "温度02";
CM_ SG_ 2400382575 CSC_Tcell_03_47 "温度03";
CM_ SG_ 2400382575 CSC_Tcell_04_47 "温度04";
CM_ SG_ 2400382575 CSC_Tcell_05_47 "温度05";
CM_ SG_ 2400382575 CSC_Tcell_06_47 "温度06";
CM_ SG_ 2400382575 CSC_Tcell_07_47 "温度07";
CM_ SG_ 2400382575 CSC_Tcell_08_47 "温度08";
CM_ SG_ 2400382575 CSC_Tcell_09_47 "温度09";
CM_ SG_ 2400382575 CSC_Tcell_10_47 "温度10";
CM_ SG_ 2400382575 CSC_Tcell_11_47 "温度11";
CM_ SG_ 2400382575 CSC_Tcell_12_47 "温度12";
CM_ SG_ 2400382575 CSC_Tcell_13_47 "温度13";
CM_ SG_ 2400382575 CSC_Tcell_14_47 "温度14";
CM_ SG_ 2400382575 CSC_Tcell_15_47 "温度15";
CM_ SG_ 2400382575 CSC_Tcell_16_47 "温度16";
CM_ SG_ 2400382575 CSC_Tcell_17_47 "温度17";
CM_ SG_ 2400382575 CSC_Tcell_18_47 "温度18";
CM_ SG_ 2400382575 CSC_Tcell_19_47 "温度19";
CM_ SG_ 2400382575 CSC_Tcell_20_47 "温度20";
CM_ SG_ 2400382575 CSC_Tcell_21_47 "温度21";
CM_ SG_ 2400382575 CSC_Tcell_22_47 "温度22";
CM_ SG_ 2400382575 CSC_Tcell_23_47 "温度23";
CM_ SG_ 2400382575 CSC_Tcell_24_47 "温度24";
CM_ SG_ 2400382575 CSC_Tcell_25_47 "温度25";
CM_ SG_ 2400382575 CSC_Tcell_26_47 "温度26";
CM_ SG_ 2400382575 CSC_Tcell_27_47 "温度27";
CM_ SG_ 2400382575 CSC_Tcell_28_47 "温度28";
CM_ SG_ 2400382575 CSC_Tcell_29_47 "温度29";
CM_ SG_ 2400382575 CSC_Tcell_30_47 "温度30";
CM_ SG_ 2400382575 CSC_Tcell_31_47 "温度31";
CM_ SG_ 2400382575 CSC_Tcell_32_47 "温度32";
CM_ SG_ 2400382575 CSC_Tcell_33_47 "温度33";
CM_ SG_ 2400382575 CSC_Tcell_34_47 "温度34";
CM_ SG_ 2400382575 CSC_Tcell_35_47 "温度35";
CM_ SG_ 2400382575 CSC_Tcell_36_47 "温度36";
CM_ SG_ 2400382575 CSC_Tcell_37_47 "温度37";
CM_ SG_ 2400382575 CSC_Tcell_38_47 "温度38";
CM_ SG_ 2400382575 CSC_Tcell_39_47 "温度39";
CM_ SG_ 2400382575 CSC_Tcell_40_47 "温度40";
CM_ SG_ 2400382575 CSC_Tcell_41_47 "温度41";
CM_ SG_ 2400382575 CSC_Tcell_42_47 "温度42";
CM_ SG_ 2400382575 CSC_Tcell_43_47 "温度43";
CM_ SG_ 2400382575 CSC_Tcell_44_47 "温度44";
CM_ SG_ 2400382575 CSC_Tcell_45_47 "温度45";
CM_ SG_ 2400382575 CSC_Tcell_46_47 "温度46";
CM_ SG_ 2400382575 CSC_Tcell_47_47 "温度47";
CM_ SG_ 2400382575 CSC_Tcell_48_47 "温度48";
CM_ SG_ 2400382575 CSC_Tcell_49_47 "温度49";
CM_ SG_ 2400382575 CSC_Tcell_50_47 "温度50";
CM_ SG_ 2400382575 CSC_Tcell_51_47 "温度51";
CM_ SG_ 2400382575 CSC_Tcell_52_47 "温度52";
CM_ SG_ 2400382575 CSC_Tcell_53_47 "温度53";
CM_ SG_ 2400382575 CSC_Tcell_54_47 "温度54";
CM_ SG_ 2400382575 CSC_Tcell_55_47 "温度55";
CM_ SG_ 2400382575 CSC_Tcell_56_47 "温度56";
CM_ SG_ 2400382575 CSC_Tcell_57_47 "温度57";
CM_ SG_ 2400382575 CSC_Tcell_58_47 "温度58";
CM_ SG_ 2400382575 CSC_Tcell_59_47 "温度59";
CM_ SG_ 2400382575 CSC_Tcell_60_47 "温度60";
CM_ SG_ 2400382575 CSC_Tcell_61_47 "温度61";
CM_ SG_ 2400382575 CSC_Tcell_62_47 "温度62";
CM_ SG_ 2400382575 CSC_Tcell_63_47 "温度63";
CM_ SG_ 2400382575 CSC_Tcell_64_47 "温度64";
CM_ SG_ 2400382575 CSC_Tcell_65_47 "温度65";
CM_ SG_ 2400382575 CSC_Tcell_66_47 "温度66";
CM_ SG_ 2400382575 CSC_Tcell_67_47 "温度67";
CM_ SG_ 2400382575 CSC_Tcell_68_47 "温度68";
CM_ SG_ 2400382575 CSC_Tcell_69_47 "温度69";
CM_ SG_ 2400382575 CSC_Tcell_70_47 "温度70";
CM_ SG_ 2400382575 CSC_Tcell_71_47 "温度71";
CM_ SG_ 2400382575 CSC_Tcell_72_47 "温度72";
CM_ SG_ 2400382576 CSC_T_No_48 "CSC号";
CM_ SG_ 2400382576 CSC_Tcell_Frame_Index_48 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382576 CSC_Tcell_01_48 "温度01";
CM_ SG_ 2400382576 CSC_Tcell_02_48 "温度02";
CM_ SG_ 2400382576 CSC_Tcell_03_48 "温度03";
CM_ SG_ 2400382576 CSC_Tcell_04_48 "温度04";
CM_ SG_ 2400382576 CSC_Tcell_05_48 "温度05";
CM_ SG_ 2400382576 CSC_Tcell_06_48 "温度06";
CM_ SG_ 2400382576 CSC_Tcell_07_48 "温度07";
CM_ SG_ 2400382576 CSC_Tcell_08_48 "温度08";
CM_ SG_ 2400382576 CSC_Tcell_09_48 "温度09";
CM_ SG_ 2400382576 CSC_Tcell_10_48 "温度10";
CM_ SG_ 2400382576 CSC_Tcell_11_48 "温度11";
CM_ SG_ 2400382576 CSC_Tcell_12_48 "温度12";
CM_ SG_ 2400382576 CSC_Tcell_13_48 "温度13";
CM_ SG_ 2400382576 CSC_Tcell_14_48 "温度14";
CM_ SG_ 2400382576 CSC_Tcell_15_48 "温度15";
CM_ SG_ 2400382576 CSC_Tcell_16_48 "温度16";
CM_ SG_ 2400382576 CSC_Tcell_17_48 "温度17";
CM_ SG_ 2400382576 CSC_Tcell_18_48 "温度18";
CM_ SG_ 2400382576 CSC_Tcell_19_48 "温度19";
CM_ SG_ 2400382576 CSC_Tcell_20_48 "温度20";
CM_ SG_ 2400382576 CSC_Tcell_21_48 "温度21";
CM_ SG_ 2400382576 CSC_Tcell_22_48 "温度22";
CM_ SG_ 2400382576 CSC_Tcell_23_48 "温度23";
CM_ SG_ 2400382576 CSC_Tcell_24_48 "温度24";
CM_ SG_ 2400382576 CSC_Tcell_25_48 "温度25";
CM_ SG_ 2400382576 CSC_Tcell_26_48 "温度26";
CM_ SG_ 2400382576 CSC_Tcell_27_48 "温度27";
CM_ SG_ 2400382576 CSC_Tcell_28_48 "温度28";
CM_ SG_ 2400382576 CSC_Tcell_29_48 "温度29";
CM_ SG_ 2400382576 CSC_Tcell_30_48 "温度30";
CM_ SG_ 2400382576 CSC_Tcell_31_48 "温度31";
CM_ SG_ 2400382576 CSC_Tcell_32_48 "温度32";
CM_ SG_ 2400382576 CSC_Tcell_33_48 "温度33";
CM_ SG_ 2400382576 CSC_Tcell_34_48 "温度34";
CM_ SG_ 2400382576 CSC_Tcell_35_48 "温度35";
CM_ SG_ 2400382576 CSC_Tcell_36_48 "温度36";
CM_ SG_ 2400382576 CSC_Tcell_37_48 "温度37";
CM_ SG_ 2400382576 CSC_Tcell_38_48 "温度38";
CM_ SG_ 2400382576 CSC_Tcell_39_48 "温度39";
CM_ SG_ 2400382576 CSC_Tcell_40_48 "温度40";
CM_ SG_ 2400382576 CSC_Tcell_41_48 "温度41";
CM_ SG_ 2400382576 CSC_Tcell_42_48 "温度42";
CM_ SG_ 2400382576 CSC_Tcell_43_48 "温度43";
CM_ SG_ 2400382576 CSC_Tcell_44_48 "温度44";
CM_ SG_ 2400382576 CSC_Tcell_45_48 "温度45";
CM_ SG_ 2400382576 CSC_Tcell_46_48 "温度46";
CM_ SG_ 2400382576 CSC_Tcell_47_48 "温度47";
CM_ SG_ 2400382576 CSC_Tcell_48_48 "温度48";
CM_ SG_ 2400382576 CSC_Tcell_49_48 "温度49";
CM_ SG_ 2400382576 CSC_Tcell_50_48 "温度50";
CM_ SG_ 2400382576 CSC_Tcell_51_48 "温度51";
CM_ SG_ 2400382576 CSC_Tcell_52_48 "温度52";
CM_ SG_ 2400382576 CSC_Tcell_53_48 "温度53";
CM_ SG_ 2400382576 CSC_Tcell_54_48 "温度54";
CM_ SG_ 2400382576 CSC_Tcell_55_48 "温度55";
CM_ SG_ 2400382576 CSC_Tcell_56_48 "温度56";
CM_ SG_ 2400382576 CSC_Tcell_57_48 "温度57";
CM_ SG_ 2400382576 CSC_Tcell_58_48 "温度58";
CM_ SG_ 2400382576 CSC_Tcell_59_48 "温度59";
CM_ SG_ 2400382576 CSC_Tcell_60_48 "温度60";
CM_ SG_ 2400382576 CSC_Tcell_61_48 "温度61";
CM_ SG_ 2400382576 CSC_Tcell_62_48 "温度62";
CM_ SG_ 2400382576 CSC_Tcell_63_48 "温度63";
CM_ SG_ 2400382576 CSC_Tcell_64_48 "温度64";
CM_ SG_ 2400382576 CSC_Tcell_65_48 "温度65";
CM_ SG_ 2400382576 CSC_Tcell_66_48 "温度66";
CM_ SG_ 2400382576 CSC_Tcell_67_48 "温度67";
CM_ SG_ 2400382576 CSC_Tcell_68_48 "温度68";
CM_ SG_ 2400382576 CSC_Tcell_69_48 "温度69";
CM_ SG_ 2400382576 CSC_Tcell_70_48 "温度70";
CM_ SG_ 2400382576 CSC_Tcell_71_48 "温度71";
CM_ SG_ 2400382576 CSC_Tcell_72_48 "温度72";
CM_ SG_ 2400382577 CSC_T_No_49 "CSC号";
CM_ SG_ 2400382577 CSC_Tcell_Frame_Index_49 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382577 CSC_Tcell_01_49 "温度01";
CM_ SG_ 2400382577 CSC_Tcell_02_49 "温度02";
CM_ SG_ 2400382577 CSC_Tcell_03_49 "温度03";
CM_ SG_ 2400382577 CSC_Tcell_04_49 "温度04";
CM_ SG_ 2400382577 CSC_Tcell_05_49 "温度05";
CM_ SG_ 2400382577 CSC_Tcell_06_49 "温度06";
CM_ SG_ 2400382577 CSC_Tcell_07_49 "温度07";
CM_ SG_ 2400382577 CSC_Tcell_08_49 "温度08";
CM_ SG_ 2400382577 CSC_Tcell_09_49 "温度09";
CM_ SG_ 2400382577 CSC_Tcell_10_49 "温度10";
CM_ SG_ 2400382577 CSC_Tcell_11_49 "温度11";
CM_ SG_ 2400382577 CSC_Tcell_12_49 "温度12";
CM_ SG_ 2400382577 CSC_Tcell_13_49 "温度13";
CM_ SG_ 2400382577 CSC_Tcell_14_49 "温度14";
CM_ SG_ 2400382577 CSC_Tcell_15_49 "温度15";
CM_ SG_ 2400382577 CSC_Tcell_16_49 "温度16";
CM_ SG_ 2400382577 CSC_Tcell_17_49 "温度17";
CM_ SG_ 2400382577 CSC_Tcell_18_49 "温度18";
CM_ SG_ 2400382577 CSC_Tcell_19_49 "温度19";
CM_ SG_ 2400382577 CSC_Tcell_20_49 "温度20";
CM_ SG_ 2400382577 CSC_Tcell_21_49 "温度21";
CM_ SG_ 2400382577 CSC_Tcell_22_49 "温度22";
CM_ SG_ 2400382577 CSC_Tcell_23_49 "温度23";
CM_ SG_ 2400382577 CSC_Tcell_24_49 "温度24";
CM_ SG_ 2400382577 CSC_Tcell_25_49 "温度25";
CM_ SG_ 2400382577 CSC_Tcell_26_49 "温度26";
CM_ SG_ 2400382577 CSC_Tcell_27_49 "温度27";
CM_ SG_ 2400382577 CSC_Tcell_28_49 "温度28";
CM_ SG_ 2400382577 CSC_Tcell_29_49 "温度29";
CM_ SG_ 2400382577 CSC_Tcell_30_49 "温度30";
CM_ SG_ 2400382577 CSC_Tcell_31_49 "温度31";
CM_ SG_ 2400382577 CSC_Tcell_32_49 "温度32";
CM_ SG_ 2400382577 CSC_Tcell_33_49 "温度33";
CM_ SG_ 2400382577 CSC_Tcell_34_49 "温度34";
CM_ SG_ 2400382577 CSC_Tcell_35_49 "温度35";
CM_ SG_ 2400382577 CSC_Tcell_36_49 "温度36";
CM_ SG_ 2400382577 CSC_Tcell_37_49 "温度37";
CM_ SG_ 2400382577 CSC_Tcell_38_49 "温度38";
CM_ SG_ 2400382577 CSC_Tcell_39_49 "温度39";
CM_ SG_ 2400382577 CSC_Tcell_40_49 "温度40";
CM_ SG_ 2400382577 CSC_Tcell_41_49 "温度41";
CM_ SG_ 2400382577 CSC_Tcell_42_49 "温度42";
CM_ SG_ 2400382577 CSC_Tcell_43_49 "温度43";
CM_ SG_ 2400382577 CSC_Tcell_44_49 "温度44";
CM_ SG_ 2400382577 CSC_Tcell_45_49 "温度45";
CM_ SG_ 2400382577 CSC_Tcell_46_49 "温度46";
CM_ SG_ 2400382577 CSC_Tcell_47_49 "温度47";
CM_ SG_ 2400382577 CSC_Tcell_48_49 "温度48";
CM_ SG_ 2400382577 CSC_Tcell_49_49 "温度49";
CM_ SG_ 2400382577 CSC_Tcell_50_49 "温度50";
CM_ SG_ 2400382577 CSC_Tcell_51_49 "温度51";
CM_ SG_ 2400382577 CSC_Tcell_52_49 "温度52";
CM_ SG_ 2400382577 CSC_Tcell_53_49 "温度53";
CM_ SG_ 2400382577 CSC_Tcell_54_49 "温度54";
CM_ SG_ 2400382577 CSC_Tcell_55_49 "温度55";
CM_ SG_ 2400382577 CSC_Tcell_56_49 "温度56";
CM_ SG_ 2400382577 CSC_Tcell_57_49 "温度57";
CM_ SG_ 2400382577 CSC_Tcell_58_49 "温度58";
CM_ SG_ 2400382577 CSC_Tcell_59_49 "温度59";
CM_ SG_ 2400382577 CSC_Tcell_60_49 "温度60";
CM_ SG_ 2400382577 CSC_Tcell_61_49 "温度61";
CM_ SG_ 2400382577 CSC_Tcell_62_49 "温度62";
CM_ SG_ 2400382577 CSC_Tcell_63_49 "温度63";
CM_ SG_ 2400382577 CSC_Tcell_64_49 "温度64";
CM_ SG_ 2400382577 CSC_Tcell_65_49 "温度65";
CM_ SG_ 2400382577 CSC_Tcell_66_49 "温度66";
CM_ SG_ 2400382577 CSC_Tcell_67_49 "温度67";
CM_ SG_ 2400382577 CSC_Tcell_68_49 "温度68";
CM_ SG_ 2400382577 CSC_Tcell_69_49 "温度69";
CM_ SG_ 2400382577 CSC_Tcell_70_49 "温度70";
CM_ SG_ 2400382577 CSC_Tcell_71_49 "温度71";
CM_ SG_ 2400382577 CSC_Tcell_72_49 "温度72";
CM_ SG_ 2400382578 CSC_T_No_50 "CSC号";
CM_ SG_ 2400382578 CSC_Tcell_Frame_Index_50 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382578 CSC_Tcell_01_50 "温度01";
CM_ SG_ 2400382578 CSC_Tcell_02_50 "温度02";
CM_ SG_ 2400382578 CSC_Tcell_03_50 "温度03";
CM_ SG_ 2400382578 CSC_Tcell_04_50 "温度04";
CM_ SG_ 2400382578 CSC_Tcell_05_50 "温度05";
CM_ SG_ 2400382578 CSC_Tcell_06_50 "温度06";
CM_ SG_ 2400382578 CSC_Tcell_07_50 "温度07";
CM_ SG_ 2400382578 CSC_Tcell_08_50 "温度08";
CM_ SG_ 2400382578 CSC_Tcell_09_50 "温度09";
CM_ SG_ 2400382578 CSC_Tcell_10_50 "温度10";
CM_ SG_ 2400382578 CSC_Tcell_11_50 "温度11";
CM_ SG_ 2400382578 CSC_Tcell_12_50 "温度12";
CM_ SG_ 2400382578 CSC_Tcell_13_50 "温度13";
CM_ SG_ 2400382578 CSC_Tcell_14_50 "温度14";
CM_ SG_ 2400382578 CSC_Tcell_15_50 "温度15";
CM_ SG_ 2400382578 CSC_Tcell_16_50 "温度16";
CM_ SG_ 2400382578 CSC_Tcell_17_50 "温度17";
CM_ SG_ 2400382578 CSC_Tcell_18_50 "温度18";
CM_ SG_ 2400382578 CSC_Tcell_19_50 "温度19";
CM_ SG_ 2400382578 CSC_Tcell_20_50 "温度20";
CM_ SG_ 2400382578 CSC_Tcell_21_50 "温度21";
CM_ SG_ 2400382578 CSC_Tcell_22_50 "温度22";
CM_ SG_ 2400382578 CSC_Tcell_23_50 "温度23";
CM_ SG_ 2400382578 CSC_Tcell_24_50 "温度24";
CM_ SG_ 2400382578 CSC_Tcell_25_50 "温度25";
CM_ SG_ 2400382578 CSC_Tcell_26_50 "温度26";
CM_ SG_ 2400382578 CSC_Tcell_27_50 "温度27";
CM_ SG_ 2400382578 CSC_Tcell_28_50 "温度28";
CM_ SG_ 2400382578 CSC_Tcell_29_50 "温度29";
CM_ SG_ 2400382578 CSC_Tcell_30_50 "温度30";
CM_ SG_ 2400382578 CSC_Tcell_31_50 "温度31";
CM_ SG_ 2400382578 CSC_Tcell_32_50 "温度32";
CM_ SG_ 2400382578 CSC_Tcell_33_50 "温度33";
CM_ SG_ 2400382578 CSC_Tcell_34_50 "温度34";
CM_ SG_ 2400382578 CSC_Tcell_35_50 "温度35";
CM_ SG_ 2400382578 CSC_Tcell_36_50 "温度36";
CM_ SG_ 2400382578 CSC_Tcell_37_50 "温度37";
CM_ SG_ 2400382578 CSC_Tcell_38_50 "温度38";
CM_ SG_ 2400382578 CSC_Tcell_39_50 "温度39";
CM_ SG_ 2400382578 CSC_Tcell_40_50 "温度40";
CM_ SG_ 2400382578 CSC_Tcell_41_50 "温度41";
CM_ SG_ 2400382578 CSC_Tcell_42_50 "温度42";
CM_ SG_ 2400382578 CSC_Tcell_43_50 "温度43";
CM_ SG_ 2400382578 CSC_Tcell_44_50 "温度44";
CM_ SG_ 2400382578 CSC_Tcell_45_50 "温度45";
CM_ SG_ 2400382578 CSC_Tcell_46_50 "温度46";
CM_ SG_ 2400382578 CSC_Tcell_47_50 "温度47";
CM_ SG_ 2400382578 CSC_Tcell_48_50 "温度48";
CM_ SG_ 2400382578 CSC_Tcell_49_50 "温度49";
CM_ SG_ 2400382578 CSC_Tcell_50_50 "温度50";
CM_ SG_ 2400382578 CSC_Tcell_51_50 "温度51";
CM_ SG_ 2400382578 CSC_Tcell_52_50 "温度52";
CM_ SG_ 2400382578 CSC_Tcell_53_50 "温度53";
CM_ SG_ 2400382578 CSC_Tcell_54_50 "温度54";
CM_ SG_ 2400382578 CSC_Tcell_55_50 "温度55";
CM_ SG_ 2400382578 CSC_Tcell_56_50 "温度56";
CM_ SG_ 2400382578 CSC_Tcell_57_50 "温度57";
CM_ SG_ 2400382578 CSC_Tcell_58_50 "温度58";
CM_ SG_ 2400382578 CSC_Tcell_59_50 "温度59";
CM_ SG_ 2400382578 CSC_Tcell_60_50 "温度60";
CM_ SG_ 2400382578 CSC_Tcell_61_50 "温度61";
CM_ SG_ 2400382578 CSC_Tcell_62_50 "温度62";
CM_ SG_ 2400382578 CSC_Tcell_63_50 "温度63";
CM_ SG_ 2400382578 CSC_Tcell_64_50 "温度64";
CM_ SG_ 2400382578 CSC_Tcell_65_50 "温度65";
CM_ SG_ 2400382578 CSC_Tcell_66_50 "温度66";
CM_ SG_ 2400382578 CSC_Tcell_67_50 "温度67";
CM_ SG_ 2400382578 CSC_Tcell_68_50 "温度68";
CM_ SG_ 2400382578 CSC_Tcell_69_50 "温度69";
CM_ SG_ 2400382578 CSC_Tcell_70_50 "温度70";
CM_ SG_ 2400382578 CSC_Tcell_71_50 "温度71";
CM_ SG_ 2400382578 CSC_Tcell_72_50 "温度72";
CM_ SG_ 2400382579 CSC_T_No_51 "CSC号";
CM_ SG_ 2400382579 CSC_Tcell_Frame_Index_51 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382579 CSC_Tcell_01_51 "温度01";
CM_ SG_ 2400382579 CSC_Tcell_02_51 "温度02";
CM_ SG_ 2400382579 CSC_Tcell_03_51 "温度03";
CM_ SG_ 2400382579 CSC_Tcell_04_51 "温度04";
CM_ SG_ 2400382579 CSC_Tcell_05_51 "温度05";
CM_ SG_ 2400382579 CSC_Tcell_06_51 "温度06";
CM_ SG_ 2400382579 CSC_Tcell_07_51 "温度07";
CM_ SG_ 2400382579 CSC_Tcell_08_51 "温度08";
CM_ SG_ 2400382579 CSC_Tcell_09_51 "温度09";
CM_ SG_ 2400382579 CSC_Tcell_10_51 "温度10";
CM_ SG_ 2400382579 CSC_Tcell_11_51 "温度11";
CM_ SG_ 2400382579 CSC_Tcell_12_51 "温度12";
CM_ SG_ 2400382579 CSC_Tcell_13_51 "温度13";
CM_ SG_ 2400382579 CSC_Tcell_14_51 "温度14";
CM_ SG_ 2400382579 CSC_Tcell_15_51 "温度15";
CM_ SG_ 2400382579 CSC_Tcell_16_51 "温度16";
CM_ SG_ 2400382579 CSC_Tcell_17_51 "温度17";
CM_ SG_ 2400382579 CSC_Tcell_18_51 "温度18";
CM_ SG_ 2400382579 CSC_Tcell_19_51 "温度19";
CM_ SG_ 2400382579 CSC_Tcell_20_51 "温度20";
CM_ SG_ 2400382579 CSC_Tcell_21_51 "温度21";
CM_ SG_ 2400382579 CSC_Tcell_22_51 "温度22";
CM_ SG_ 2400382579 CSC_Tcell_23_51 "温度23";
CM_ SG_ 2400382579 CSC_Tcell_24_51 "温度24";
CM_ SG_ 2400382579 CSC_Tcell_25_51 "温度25";
CM_ SG_ 2400382579 CSC_Tcell_26_51 "温度26";
CM_ SG_ 2400382579 CSC_Tcell_27_51 "温度27";
CM_ SG_ 2400382579 CSC_Tcell_28_51 "温度28";
CM_ SG_ 2400382579 CSC_Tcell_29_51 "温度29";
CM_ SG_ 2400382579 CSC_Tcell_30_51 "温度30";
CM_ SG_ 2400382579 CSC_Tcell_31_51 "温度31";
CM_ SG_ 2400382579 CSC_Tcell_32_51 "温度32";
CM_ SG_ 2400382579 CSC_Tcell_33_51 "温度33";
CM_ SG_ 2400382579 CSC_Tcell_34_51 "温度34";
CM_ SG_ 2400382579 CSC_Tcell_35_51 "温度35";
CM_ SG_ 2400382579 CSC_Tcell_36_51 "温度36";
CM_ SG_ 2400382579 CSC_Tcell_37_51 "温度37";
CM_ SG_ 2400382579 CSC_Tcell_38_51 "温度38";
CM_ SG_ 2400382579 CSC_Tcell_39_51 "温度39";
CM_ SG_ 2400382579 CSC_Tcell_40_51 "温度40";
CM_ SG_ 2400382579 CSC_Tcell_41_51 "温度41";
CM_ SG_ 2400382579 CSC_Tcell_42_51 "温度42";
CM_ SG_ 2400382579 CSC_Tcell_43_51 "温度43";
CM_ SG_ 2400382579 CSC_Tcell_44_51 "温度44";
CM_ SG_ 2400382579 CSC_Tcell_45_51 "温度45";
CM_ SG_ 2400382579 CSC_Tcell_46_51 "温度46";
CM_ SG_ 2400382579 CSC_Tcell_47_51 "温度47";
CM_ SG_ 2400382579 CSC_Tcell_48_51 "温度48";
CM_ SG_ 2400382579 CSC_Tcell_49_51 "温度49";
CM_ SG_ 2400382579 CSC_Tcell_50_51 "温度50";
CM_ SG_ 2400382579 CSC_Tcell_51_51 "温度51";
CM_ SG_ 2400382579 CSC_Tcell_52_51 "温度52";
CM_ SG_ 2400382579 CSC_Tcell_53_51 "温度53";
CM_ SG_ 2400382579 CSC_Tcell_54_51 "温度54";
CM_ SG_ 2400382579 CSC_Tcell_55_51 "温度55";
CM_ SG_ 2400382579 CSC_Tcell_56_51 "温度56";
CM_ SG_ 2400382579 CSC_Tcell_57_51 "温度57";
CM_ SG_ 2400382579 CSC_Tcell_58_51 "温度58";
CM_ SG_ 2400382579 CSC_Tcell_59_51 "温度59";
CM_ SG_ 2400382579 CSC_Tcell_60_51 "温度60";
CM_ SG_ 2400382579 CSC_Tcell_61_51 "温度61";
CM_ SG_ 2400382579 CSC_Tcell_62_51 "温度62";
CM_ SG_ 2400382579 CSC_Tcell_63_51 "温度63";
CM_ SG_ 2400382579 CSC_Tcell_64_51 "温度64";
CM_ SG_ 2400382579 CSC_Tcell_65_51 "温度65";
CM_ SG_ 2400382579 CSC_Tcell_66_51 "温度66";
CM_ SG_ 2400382579 CSC_Tcell_67_51 "温度67";
CM_ SG_ 2400382579 CSC_Tcell_68_51 "温度68";
CM_ SG_ 2400382579 CSC_Tcell_69_51 "温度69";
CM_ SG_ 2400382579 CSC_Tcell_70_51 "温度70";
CM_ SG_ 2400382579 CSC_Tcell_71_51 "温度71";
CM_ SG_ 2400382579 CSC_Tcell_72_51 "温度72";
CM_ SG_ 2400382580 CSC_T_No_52 "CSC号";
CM_ SG_ 2400382580 CSC_Tcell_Frame_Index_52 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382580 CSC_Tcell_01_52 "温度01";
CM_ SG_ 2400382580 CSC_Tcell_02_52 "温度02";
CM_ SG_ 2400382580 CSC_Tcell_03_52 "温度03";
CM_ SG_ 2400382580 CSC_Tcell_04_52 "温度04";
CM_ SG_ 2400382580 CSC_Tcell_05_52 "温度05";
CM_ SG_ 2400382580 CSC_Tcell_06_52 "温度06";
CM_ SG_ 2400382580 CSC_Tcell_07_52 "温度07";
CM_ SG_ 2400382580 CSC_Tcell_08_52 "温度08";
CM_ SG_ 2400382580 CSC_Tcell_09_52 "温度09";
CM_ SG_ 2400382580 CSC_Tcell_10_52 "温度10";
CM_ SG_ 2400382580 CSC_Tcell_11_52 "温度11";
CM_ SG_ 2400382580 CSC_Tcell_12_52 "温度12";
CM_ SG_ 2400382580 CSC_Tcell_13_52 "温度13";
CM_ SG_ 2400382580 CSC_Tcell_14_52 "温度14";
CM_ SG_ 2400382580 CSC_Tcell_15_52 "温度15";
CM_ SG_ 2400382580 CSC_Tcell_16_52 "温度16";
CM_ SG_ 2400382580 CSC_Tcell_17_52 "温度17";
CM_ SG_ 2400382580 CSC_Tcell_18_52 "温度18";
CM_ SG_ 2400382580 CSC_Tcell_19_52 "温度19";
CM_ SG_ 2400382580 CSC_Tcell_20_52 "温度20";
CM_ SG_ 2400382580 CSC_Tcell_21_52 "温度21";
CM_ SG_ 2400382580 CSC_Tcell_22_52 "温度22";
CM_ SG_ 2400382580 CSC_Tcell_23_52 "温度23";
CM_ SG_ 2400382580 CSC_Tcell_24_52 "温度24";
CM_ SG_ 2400382580 CSC_Tcell_25_52 "温度25";
CM_ SG_ 2400382580 CSC_Tcell_26_52 "温度26";
CM_ SG_ 2400382580 CSC_Tcell_27_52 "温度27";
CM_ SG_ 2400382580 CSC_Tcell_28_52 "温度28";
CM_ SG_ 2400382580 CSC_Tcell_29_52 "温度29";
CM_ SG_ 2400382580 CSC_Tcell_30_52 "温度30";
CM_ SG_ 2400382580 CSC_Tcell_31_52 "温度31";
CM_ SG_ 2400382580 CSC_Tcell_32_52 "温度32";
CM_ SG_ 2400382580 CSC_Tcell_33_52 "温度33";
CM_ SG_ 2400382580 CSC_Tcell_34_52 "温度34";
CM_ SG_ 2400382580 CSC_Tcell_35_52 "温度35";
CM_ SG_ 2400382580 CSC_Tcell_36_52 "温度36";
CM_ SG_ 2400382580 CSC_Tcell_37_52 "温度37";
CM_ SG_ 2400382580 CSC_Tcell_38_52 "温度38";
CM_ SG_ 2400382580 CSC_Tcell_39_52 "温度39";
CM_ SG_ 2400382580 CSC_Tcell_40_52 "温度40";
CM_ SG_ 2400382580 CSC_Tcell_41_52 "温度41";
CM_ SG_ 2400382580 CSC_Tcell_42_52 "温度42";
CM_ SG_ 2400382580 CSC_Tcell_43_52 "温度43";
CM_ SG_ 2400382580 CSC_Tcell_44_52 "温度44";
CM_ SG_ 2400382580 CSC_Tcell_45_52 "温度45";
CM_ SG_ 2400382580 CSC_Tcell_46_52 "温度46";
CM_ SG_ 2400382580 CSC_Tcell_47_52 "温度47";
CM_ SG_ 2400382580 CSC_Tcell_48_52 "温度48";
CM_ SG_ 2400382580 CSC_Tcell_49_52 "温度49";
CM_ SG_ 2400382580 CSC_Tcell_50_52 "温度50";
CM_ SG_ 2400382580 CSC_Tcell_51_52 "温度51";
CM_ SG_ 2400382580 CSC_Tcell_52_52 "温度52";
CM_ SG_ 2400382580 CSC_Tcell_53_52 "温度53";
CM_ SG_ 2400382580 CSC_Tcell_54_52 "温度54";
CM_ SG_ 2400382580 CSC_Tcell_55_52 "温度55";
CM_ SG_ 2400382580 CSC_Tcell_56_52 "温度56";
CM_ SG_ 2400382580 CSC_Tcell_57_52 "温度57";
CM_ SG_ 2400382580 CSC_Tcell_58_52 "温度58";
CM_ SG_ 2400382580 CSC_Tcell_59_52 "温度59";
CM_ SG_ 2400382580 CSC_Tcell_60_52 "温度60";
CM_ SG_ 2400382580 CSC_Tcell_61_52 "温度61";
CM_ SG_ 2400382580 CSC_Tcell_62_52 "温度62";
CM_ SG_ 2400382580 CSC_Tcell_63_52 "温度63";
CM_ SG_ 2400382580 CSC_Tcell_64_52 "温度64";
CM_ SG_ 2400382580 CSC_Tcell_65_52 "温度65";
CM_ SG_ 2400382580 CSC_Tcell_66_52 "温度66";
CM_ SG_ 2400382580 CSC_Tcell_67_52 "温度67";
CM_ SG_ 2400382580 CSC_Tcell_68_52 "温度68";
CM_ SG_ 2400382580 CSC_Tcell_69_52 "温度69";
CM_ SG_ 2400382580 CSC_Tcell_70_52 "温度70";
CM_ SG_ 2400382580 CSC_Tcell_71_52 "温度71";
CM_ SG_ 2400382580 CSC_Tcell_72_52 "温度72";
CM_ SG_ 2400382581 CSC_T_No_53 "CSC号";
CM_ SG_ 2400382581 CSC_Tcell_Frame_Index_53 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382581 CSC_Tcell_01_53 "温度01";
CM_ SG_ 2400382581 CSC_Tcell_02_53 "温度02";
CM_ SG_ 2400382581 CSC_Tcell_03_53 "温度03";
CM_ SG_ 2400382581 CSC_Tcell_04_53 "温度04";
CM_ SG_ 2400382581 CSC_Tcell_05_53 "温度05";
CM_ SG_ 2400382581 CSC_Tcell_06_53 "温度06";
CM_ SG_ 2400382581 CSC_Tcell_07_53 "温度07";
CM_ SG_ 2400382581 CSC_Tcell_08_53 "温度08";
CM_ SG_ 2400382581 CSC_Tcell_09_53 "温度09";
CM_ SG_ 2400382581 CSC_Tcell_10_53 "温度10";
CM_ SG_ 2400382581 CSC_Tcell_11_53 "温度11";
CM_ SG_ 2400382581 CSC_Tcell_12_53 "温度12";
CM_ SG_ 2400382581 CSC_Tcell_13_53 "温度13";
CM_ SG_ 2400382581 CSC_Tcell_14_53 "温度14";
CM_ SG_ 2400382581 CSC_Tcell_15_53 "温度15";
CM_ SG_ 2400382581 CSC_Tcell_16_53 "温度16";
CM_ SG_ 2400382581 CSC_Tcell_17_53 "温度17";
CM_ SG_ 2400382581 CSC_Tcell_18_53 "温度18";
CM_ SG_ 2400382581 CSC_Tcell_19_53 "温度19";
CM_ SG_ 2400382581 CSC_Tcell_20_53 "温度20";
CM_ SG_ 2400382581 CSC_Tcell_21_53 "温度21";
CM_ SG_ 2400382581 CSC_Tcell_22_53 "温度22";
CM_ SG_ 2400382581 CSC_Tcell_23_53 "温度23";
CM_ SG_ 2400382581 CSC_Tcell_24_53 "温度24";
CM_ SG_ 2400382581 CSC_Tcell_25_53 "温度25";
CM_ SG_ 2400382581 CSC_Tcell_26_53 "温度26";
CM_ SG_ 2400382581 CSC_Tcell_27_53 "温度27";
CM_ SG_ 2400382581 CSC_Tcell_28_53 "温度28";
CM_ SG_ 2400382581 CSC_Tcell_29_53 "温度29";
CM_ SG_ 2400382581 CSC_Tcell_30_53 "温度30";
CM_ SG_ 2400382581 CSC_Tcell_31_53 "温度31";
CM_ SG_ 2400382581 CSC_Tcell_32_53 "温度32";
CM_ SG_ 2400382581 CSC_Tcell_33_53 "温度33";
CM_ SG_ 2400382581 CSC_Tcell_34_53 "温度34";
CM_ SG_ 2400382581 CSC_Tcell_35_53 "温度35";
CM_ SG_ 2400382581 CSC_Tcell_36_53 "温度36";
CM_ SG_ 2400382581 CSC_Tcell_37_53 "温度37";
CM_ SG_ 2400382581 CSC_Tcell_38_53 "温度38";
CM_ SG_ 2400382581 CSC_Tcell_39_53 "温度39";
CM_ SG_ 2400382581 CSC_Tcell_40_53 "温度40";
CM_ SG_ 2400382581 CSC_Tcell_41_53 "温度41";
CM_ SG_ 2400382581 CSC_Tcell_42_53 "温度42";
CM_ SG_ 2400382581 CSC_Tcell_43_53 "温度43";
CM_ SG_ 2400382581 CSC_Tcell_44_53 "温度44";
CM_ SG_ 2400382581 CSC_Tcell_45_53 "温度45";
CM_ SG_ 2400382581 CSC_Tcell_46_53 "温度46";
CM_ SG_ 2400382581 CSC_Tcell_47_53 "温度47";
CM_ SG_ 2400382581 CSC_Tcell_48_53 "温度48";
CM_ SG_ 2400382581 CSC_Tcell_49_53 "温度49";
CM_ SG_ 2400382581 CSC_Tcell_50_53 "温度50";
CM_ SG_ 2400382581 CSC_Tcell_51_53 "温度51";
CM_ SG_ 2400382581 CSC_Tcell_52_53 "温度52";
CM_ SG_ 2400382581 CSC_Tcell_53_53 "温度53";
CM_ SG_ 2400382581 CSC_Tcell_54_53 "温度54";
CM_ SG_ 2400382581 CSC_Tcell_55_53 "温度55";
CM_ SG_ 2400382581 CSC_Tcell_56_53 "温度56";
CM_ SG_ 2400382581 CSC_Tcell_57_53 "温度57";
CM_ SG_ 2400382581 CSC_Tcell_58_53 "温度58";
CM_ SG_ 2400382581 CSC_Tcell_59_53 "温度59";
CM_ SG_ 2400382581 CSC_Tcell_60_53 "温度60";
CM_ SG_ 2400382581 CSC_Tcell_61_53 "温度61";
CM_ SG_ 2400382581 CSC_Tcell_62_53 "温度62";
CM_ SG_ 2400382581 CSC_Tcell_63_53 "温度63";
CM_ SG_ 2400382581 CSC_Tcell_64_53 "温度64";
CM_ SG_ 2400382581 CSC_Tcell_65_53 "温度65";
CM_ SG_ 2400382581 CSC_Tcell_66_53 "温度66";
CM_ SG_ 2400382581 CSC_Tcell_67_53 "温度67";
CM_ SG_ 2400382581 CSC_Tcell_68_53 "温度68";
CM_ SG_ 2400382581 CSC_Tcell_69_53 "温度69";
CM_ SG_ 2400382581 CSC_Tcell_70_53 "温度70";
CM_ SG_ 2400382581 CSC_Tcell_71_53 "温度71";
CM_ SG_ 2400382581 CSC_Tcell_72_53 "温度72";
CM_ SG_ 2400382582 CSC_T_No_54 "CSC号";
CM_ SG_ 2400382582 CSC_Tcell_Frame_Index_54 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382582 CSC_Tcell_01_54 "温度01";
CM_ SG_ 2400382582 CSC_Tcell_02_54 "温度02";
CM_ SG_ 2400382582 CSC_Tcell_03_54 "温度03";
CM_ SG_ 2400382582 CSC_Tcell_04_54 "温度04";
CM_ SG_ 2400382582 CSC_Tcell_05_54 "温度05";
CM_ SG_ 2400382582 CSC_Tcell_06_54 "温度06";
CM_ SG_ 2400382582 CSC_Tcell_07_54 "温度07";
CM_ SG_ 2400382582 CSC_Tcell_08_54 "温度08";
CM_ SG_ 2400382582 CSC_Tcell_09_54 "温度09";
CM_ SG_ 2400382582 CSC_Tcell_10_54 "温度10";
CM_ SG_ 2400382582 CSC_Tcell_11_54 "温度11";
CM_ SG_ 2400382582 CSC_Tcell_12_54 "温度12";
CM_ SG_ 2400382582 CSC_Tcell_13_54 "温度13";
CM_ SG_ 2400382582 CSC_Tcell_14_54 "温度14";
CM_ SG_ 2400382582 CSC_Tcell_15_54 "温度15";
CM_ SG_ 2400382582 CSC_Tcell_16_54 "温度16";
CM_ SG_ 2400382582 CSC_Tcell_17_54 "温度17";
CM_ SG_ 2400382582 CSC_Tcell_18_54 "温度18";
CM_ SG_ 2400382582 CSC_Tcell_19_54 "温度19";
CM_ SG_ 2400382582 CSC_Tcell_20_54 "温度20";
CM_ SG_ 2400382582 CSC_Tcell_21_54 "温度21";
CM_ SG_ 2400382582 CSC_Tcell_22_54 "温度22";
CM_ SG_ 2400382582 CSC_Tcell_23_54 "温度23";
CM_ SG_ 2400382582 CSC_Tcell_24_54 "温度24";
CM_ SG_ 2400382582 CSC_Tcell_25_54 "温度25";
CM_ SG_ 2400382582 CSC_Tcell_26_54 "温度26";
CM_ SG_ 2400382582 CSC_Tcell_27_54 "温度27";
CM_ SG_ 2400382582 CSC_Tcell_28_54 "温度28";
CM_ SG_ 2400382582 CSC_Tcell_29_54 "温度29";
CM_ SG_ 2400382582 CSC_Tcell_30_54 "温度30";
CM_ SG_ 2400382582 CSC_Tcell_31_54 "温度31";
CM_ SG_ 2400382582 CSC_Tcell_32_54 "温度32";
CM_ SG_ 2400382582 CSC_Tcell_33_54 "温度33";
CM_ SG_ 2400382582 CSC_Tcell_34_54 "温度34";
CM_ SG_ 2400382582 CSC_Tcell_35_54 "温度35";
CM_ SG_ 2400382582 CSC_Tcell_36_54 "温度36";
CM_ SG_ 2400382582 CSC_Tcell_37_54 "温度37";
CM_ SG_ 2400382582 CSC_Tcell_38_54 "温度38";
CM_ SG_ 2400382582 CSC_Tcell_39_54 "温度39";
CM_ SG_ 2400382582 CSC_Tcell_40_54 "温度40";
CM_ SG_ 2400382582 CSC_Tcell_41_54 "温度41";
CM_ SG_ 2400382582 CSC_Tcell_42_54 "温度42";
CM_ SG_ 2400382582 CSC_Tcell_43_54 "温度43";
CM_ SG_ 2400382582 CSC_Tcell_44_54 "温度44";
CM_ SG_ 2400382582 CSC_Tcell_45_54 "温度45";
CM_ SG_ 2400382582 CSC_Tcell_46_54 "温度46";
CM_ SG_ 2400382582 CSC_Tcell_47_54 "温度47";
CM_ SG_ 2400382582 CSC_Tcell_48_54 "温度48";
CM_ SG_ 2400382582 CSC_Tcell_49_54 "温度49";
CM_ SG_ 2400382582 CSC_Tcell_50_54 "温度50";
CM_ SG_ 2400382582 CSC_Tcell_51_54 "温度51";
CM_ SG_ 2400382582 CSC_Tcell_52_54 "温度52";
CM_ SG_ 2400382582 CSC_Tcell_53_54 "温度53";
CM_ SG_ 2400382582 CSC_Tcell_54_54 "温度54";
CM_ SG_ 2400382582 CSC_Tcell_55_54 "温度55";
CM_ SG_ 2400382582 CSC_Tcell_56_54 "温度56";
CM_ SG_ 2400382582 CSC_Tcell_57_54 "温度57";
CM_ SG_ 2400382582 CSC_Tcell_58_54 "温度58";
CM_ SG_ 2400382582 CSC_Tcell_59_54 "温度59";
CM_ SG_ 2400382582 CSC_Tcell_60_54 "温度60";
CM_ SG_ 2400382582 CSC_Tcell_61_54 "温度61";
CM_ SG_ 2400382582 CSC_Tcell_62_54 "温度62";
CM_ SG_ 2400382582 CSC_Tcell_63_54 "温度63";
CM_ SG_ 2400382582 CSC_Tcell_64_54 "温度64";
CM_ SG_ 2400382582 CSC_Tcell_65_54 "温度65";
CM_ SG_ 2400382582 CSC_Tcell_66_54 "温度66";
CM_ SG_ 2400382582 CSC_Tcell_67_54 "温度67";
CM_ SG_ 2400382582 CSC_Tcell_68_54 "温度68";
CM_ SG_ 2400382582 CSC_Tcell_69_54 "温度69";
CM_ SG_ 2400382582 CSC_Tcell_70_54 "温度70";
CM_ SG_ 2400382582 CSC_Tcell_71_54 "温度71";
CM_ SG_ 2400382582 CSC_Tcell_72_54 "温度72";
VAL_ 2400382566 CSC_T_No_38 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382566 CSC_Tcell_01_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_02_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_03_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_04_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_05_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_06_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_07_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_08_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_09_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_10_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_11_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_12_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_13_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_14_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_15_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_16_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_17_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_18_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_19_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_20_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_21_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_22_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_23_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_24_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_25_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_26_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_27_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_28_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_29_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_30_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_31_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_32_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_33_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_34_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_35_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_36_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_37_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_38_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_39_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_40_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_41_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_42_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_43_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_44_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_45_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_46_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_47_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_48_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_49_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_50_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_51_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_52_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_53_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_54_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_55_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_56_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_57_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_58_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_59_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_60_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_61_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_62_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_63_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_64_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_65_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_66_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_67_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_68_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_69_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_70_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_71_38 255 "Invalid" ;
VAL_ 2400382566 CSC_Tcell_72_38 255 "Invalid" ;
VAL_ 2400382567 CSC_T_No_39 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382567 CSC_Tcell_01_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_02_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_03_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_04_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_05_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_06_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_07_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_08_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_09_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_10_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_11_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_12_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_13_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_14_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_15_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_16_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_17_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_18_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_19_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_20_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_21_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_22_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_23_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_24_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_25_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_26_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_27_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_28_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_29_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_30_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_31_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_32_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_33_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_34_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_35_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_36_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_37_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_38_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_39_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_40_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_41_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_42_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_43_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_44_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_45_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_46_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_47_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_48_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_49_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_50_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_51_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_52_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_53_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_54_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_55_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_56_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_57_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_58_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_59_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_60_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_61_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_62_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_63_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_64_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_65_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_66_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_67_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_68_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_69_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_70_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_71_39 255 "Invalid" ;
VAL_ 2400382567 CSC_Tcell_72_39 255 "Invalid" ;
VAL_ 2400382568 CSC_T_No_40 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382568 CSC_Tcell_01_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_02_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_03_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_04_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_05_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_06_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_07_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_08_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_09_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_10_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_11_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_12_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_13_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_14_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_15_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_16_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_17_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_18_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_19_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_20_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_21_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_22_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_23_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_24_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_25_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_26_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_27_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_28_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_29_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_30_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_31_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_32_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_33_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_34_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_35_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_36_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_37_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_38_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_39_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_40_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_41_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_42_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_43_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_44_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_45_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_46_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_47_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_48_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_49_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_50_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_51_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_52_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_53_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_54_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_55_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_56_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_57_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_58_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_59_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_60_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_61_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_62_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_63_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_64_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_65_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_66_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_67_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_68_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_69_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_70_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_71_40 255 "Invalid" ;
VAL_ 2400382568 CSC_Tcell_72_40 255 "Invalid" ;
VAL_ 2400382569 CSC_T_No_41 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382569 CSC_Tcell_01_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_02_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_03_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_04_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_05_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_06_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_07_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_08_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_09_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_10_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_11_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_12_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_13_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_14_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_15_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_16_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_17_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_18_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_19_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_20_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_21_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_22_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_23_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_24_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_25_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_26_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_27_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_28_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_29_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_30_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_31_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_32_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_33_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_34_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_35_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_36_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_37_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_38_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_39_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_40_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_41_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_42_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_43_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_44_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_45_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_46_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_47_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_48_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_49_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_50_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_51_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_52_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_53_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_54_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_55_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_56_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_57_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_58_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_59_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_60_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_61_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_62_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_63_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_64_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_65_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_66_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_67_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_68_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_69_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_70_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_71_41 255 "Invalid" ;
VAL_ 2400382569 CSC_Tcell_72_41 255 "Invalid" ;
VAL_ 2400382570 CSC_T_No_42 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382570 CSC_Tcell_01_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_02_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_03_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_04_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_05_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_06_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_07_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_08_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_09_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_10_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_11_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_12_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_13_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_14_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_15_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_16_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_17_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_18_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_19_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_20_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_21_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_22_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_23_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_24_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_25_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_26_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_27_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_28_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_29_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_30_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_31_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_32_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_33_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_34_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_35_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_36_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_37_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_38_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_39_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_40_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_41_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_42_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_43_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_44_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_45_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_46_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_47_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_48_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_49_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_50_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_51_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_52_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_53_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_54_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_55_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_56_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_57_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_58_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_59_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_60_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_61_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_62_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_63_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_64_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_65_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_66_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_67_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_68_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_69_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_70_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_71_42 255 "Invalid" ;
VAL_ 2400382570 CSC_Tcell_72_42 255 "Invalid" ;
VAL_ 2400382571 CSC_T_No_43 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382571 CSC_Tcell_01_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_02_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_03_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_04_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_05_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_06_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_07_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_08_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_09_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_10_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_11_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_12_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_13_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_14_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_15_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_16_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_17_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_18_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_19_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_20_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_21_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_22_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_23_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_24_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_25_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_26_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_27_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_28_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_29_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_30_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_31_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_32_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_33_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_34_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_35_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_36_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_37_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_38_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_39_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_40_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_41_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_42_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_43_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_44_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_45_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_46_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_47_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_48_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_49_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_50_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_51_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_52_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_53_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_54_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_55_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_56_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_57_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_58_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_59_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_60_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_61_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_62_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_63_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_64_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_65_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_66_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_67_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_68_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_69_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_70_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_71_43 255 "Invalid" ;
VAL_ 2400382571 CSC_Tcell_72_43 255 "Invalid" ;
VAL_ 2400382572 CSC_T_No_44 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382572 CSC_Tcell_01_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_02_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_03_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_04_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_05_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_06_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_07_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_08_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_09_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_10_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_11_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_12_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_13_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_14_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_15_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_16_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_17_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_18_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_19_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_20_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_21_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_22_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_23_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_24_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_25_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_26_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_27_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_28_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_29_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_30_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_31_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_32_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_33_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_34_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_35_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_36_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_37_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_38_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_39_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_40_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_41_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_42_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_43_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_44_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_45_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_46_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_47_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_48_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_49_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_50_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_51_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_52_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_53_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_54_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_55_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_56_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_57_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_58_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_59_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_60_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_61_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_62_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_63_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_64_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_65_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_66_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_67_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_68_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_69_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_70_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_71_44 255 "Invalid" ;
VAL_ 2400382572 CSC_Tcell_72_44 255 "Invalid" ;
VAL_ 2400382573 CSC_T_No_45 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382573 CSC_Tcell_01_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_02_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_03_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_04_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_05_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_06_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_07_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_08_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_09_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_10_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_11_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_12_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_13_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_14_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_15_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_16_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_17_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_18_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_19_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_20_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_21_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_22_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_23_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_24_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_25_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_26_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_27_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_28_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_29_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_30_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_31_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_32_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_33_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_34_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_35_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_36_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_37_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_38_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_39_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_40_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_41_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_42_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_43_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_44_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_45_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_46_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_47_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_48_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_49_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_50_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_51_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_52_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_53_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_54_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_55_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_56_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_57_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_58_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_59_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_60_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_61_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_62_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_63_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_64_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_65_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_66_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_67_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_68_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_69_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_70_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_71_45 255 "Invalid" ;
VAL_ 2400382573 CSC_Tcell_72_45 255 "Invalid" ;
VAL_ 2400382574 CSC_T_No_46 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382574 CSC_Tcell_01_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_02_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_03_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_04_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_05_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_06_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_07_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_08_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_09_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_10_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_11_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_12_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_13_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_14_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_15_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_16_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_17_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_18_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_19_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_20_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_21_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_22_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_23_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_24_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_25_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_26_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_27_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_28_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_29_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_30_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_31_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_32_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_33_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_34_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_35_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_36_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_37_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_38_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_39_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_40_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_41_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_42_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_43_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_44_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_45_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_46_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_47_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_48_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_49_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_50_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_51_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_52_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_53_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_54_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_55_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_56_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_57_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_58_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_59_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_60_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_61_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_62_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_63_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_64_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_65_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_66_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_67_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_68_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_69_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_70_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_71_46 255 "Invalid" ;
VAL_ 2400382574 CSC_Tcell_72_46 255 "Invalid" ;
VAL_ 2400382575 CSC_T_No_47 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382575 CSC_Tcell_01_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_02_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_03_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_04_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_05_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_06_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_07_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_08_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_09_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_10_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_11_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_12_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_13_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_14_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_15_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_16_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_17_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_18_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_19_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_20_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_21_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_22_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_23_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_24_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_25_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_26_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_27_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_28_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_29_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_30_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_31_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_32_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_33_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_34_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_35_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_36_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_37_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_38_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_39_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_40_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_41_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_42_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_43_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_44_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_45_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_46_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_47_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_48_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_49_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_50_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_51_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_52_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_53_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_54_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_55_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_56_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_57_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_58_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_59_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_60_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_61_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_62_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_63_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_64_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_65_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_66_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_67_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_68_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_69_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_70_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_71_47 255 "Invalid" ;
VAL_ 2400382575 CSC_Tcell_72_47 255 "Invalid" ;
VAL_ 2400382576 CSC_T_No_48 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382576 CSC_Tcell_01_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_02_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_03_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_04_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_05_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_06_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_07_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_08_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_09_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_10_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_11_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_12_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_13_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_14_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_15_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_16_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_17_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_18_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_19_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_20_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_21_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_22_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_23_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_24_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_25_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_26_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_27_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_28_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_29_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_30_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_31_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_32_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_33_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_34_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_35_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_36_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_37_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_38_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_39_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_40_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_41_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_42_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_43_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_44_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_45_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_46_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_47_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_48_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_49_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_50_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_51_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_52_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_53_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_54_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_55_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_56_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_57_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_58_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_59_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_60_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_61_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_62_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_63_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_64_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_65_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_66_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_67_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_68_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_69_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_70_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_71_48 255 "Invalid" ;
VAL_ 2400382576 CSC_Tcell_72_48 255 "Invalid" ;
VAL_ 2400382577 CSC_T_No_49 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382577 CSC_Tcell_01_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_02_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_03_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_04_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_05_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_06_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_07_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_08_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_09_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_10_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_11_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_12_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_13_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_14_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_15_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_16_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_17_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_18_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_19_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_20_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_21_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_22_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_23_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_24_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_25_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_26_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_27_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_28_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_29_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_30_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_31_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_32_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_33_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_34_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_35_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_36_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_37_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_38_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_39_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_40_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_41_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_42_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_43_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_44_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_45_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_46_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_47_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_48_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_49_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_50_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_51_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_52_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_53_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_54_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_55_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_56_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_57_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_58_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_59_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_60_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_61_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_62_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_63_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_64_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_65_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_66_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_67_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_68_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_69_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_70_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_71_49 255 "Invalid" ;
VAL_ 2400382577 CSC_Tcell_72_49 255 "Invalid" ;
VAL_ 2400382578 CSC_T_No_50 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382578 CSC_Tcell_01_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_02_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_03_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_04_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_05_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_06_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_07_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_08_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_09_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_10_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_11_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_12_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_13_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_14_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_15_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_16_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_17_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_18_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_19_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_20_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_21_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_22_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_23_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_24_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_25_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_26_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_27_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_28_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_29_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_30_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_31_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_32_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_33_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_34_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_35_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_36_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_37_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_38_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_39_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_40_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_41_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_42_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_43_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_44_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_45_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_46_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_47_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_48_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_49_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_50_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_51_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_52_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_53_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_54_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_55_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_56_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_57_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_58_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_59_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_60_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_61_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_62_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_63_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_64_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_65_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_66_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_67_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_68_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_69_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_70_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_71_50 255 "Invalid" ;
VAL_ 2400382578 CSC_Tcell_72_50 255 "Invalid" ;
VAL_ 2400382579 CSC_T_No_51 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382579 CSC_Tcell_01_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_02_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_03_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_04_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_05_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_06_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_07_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_08_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_09_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_10_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_11_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_12_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_13_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_14_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_15_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_16_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_17_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_18_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_19_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_20_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_21_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_22_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_23_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_24_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_25_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_26_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_27_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_28_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_29_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_30_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_31_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_32_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_33_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_34_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_35_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_36_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_37_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_38_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_39_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_40_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_41_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_42_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_43_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_44_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_45_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_46_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_47_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_48_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_49_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_50_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_51_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_52_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_53_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_54_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_55_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_56_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_57_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_58_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_59_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_60_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_61_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_62_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_63_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_64_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_65_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_66_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_67_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_68_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_69_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_70_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_71_51 255 "Invalid" ;
VAL_ 2400382579 CSC_Tcell_72_51 255 "Invalid" ;
VAL_ 2400382580 CSC_T_No_52 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382580 CSC_Tcell_01_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_02_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_03_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_04_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_05_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_06_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_07_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_08_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_09_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_10_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_11_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_12_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_13_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_14_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_15_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_16_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_17_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_18_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_19_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_20_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_21_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_22_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_23_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_24_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_25_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_26_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_27_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_28_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_29_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_30_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_31_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_32_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_33_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_34_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_35_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_36_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_37_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_38_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_39_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_40_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_41_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_42_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_43_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_44_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_45_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_46_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_47_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_48_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_49_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_50_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_51_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_52_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_53_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_54_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_55_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_56_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_57_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_58_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_59_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_60_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_61_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_62_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_63_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_64_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_65_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_66_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_67_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_68_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_69_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_70_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_71_52 255 "Invalid" ;
VAL_ 2400382580 CSC_Tcell_72_52 255 "Invalid" ;
VAL_ 2400382581 CSC_T_No_53 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382581 CSC_Tcell_01_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_02_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_03_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_04_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_05_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_06_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_07_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_08_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_09_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_10_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_11_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_12_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_13_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_14_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_15_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_16_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_17_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_18_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_19_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_20_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_21_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_22_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_23_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_24_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_25_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_26_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_27_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_28_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_29_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_30_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_31_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_32_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_33_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_34_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_35_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_36_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_37_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_38_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_39_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_40_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_41_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_42_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_43_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_44_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_45_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_46_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_47_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_48_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_49_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_50_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_51_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_52_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_53_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_54_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_55_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_56_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_57_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_58_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_59_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_60_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_61_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_62_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_63_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_64_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_65_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_66_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_67_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_68_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_69_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_70_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_71_53 255 "Invalid" ;
VAL_ 2400382581 CSC_Tcell_72_53 255 "Invalid" ;
VAL_ 2400382582 CSC_T_No_54 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382582 CSC_Tcell_01_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_02_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_03_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_04_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_05_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_06_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_07_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_08_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_09_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_10_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_11_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_12_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_13_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_14_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_15_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_16_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_17_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_18_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_19_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_20_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_21_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_22_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_23_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_24_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_25_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_26_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_27_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_28_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_29_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_30_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_31_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_32_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_33_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_34_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_35_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_36_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_37_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_38_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_39_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_40_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_41_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_42_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_43_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_44_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_45_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_46_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_47_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_48_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_49_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_50_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_51_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_52_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_53_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_54_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_55_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_56_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_57_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_58_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_59_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_60_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_61_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_62_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_63_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_64_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_65_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_66_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_67_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_68_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_69_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_70_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_71_54 255 "Invalid" ;
VAL_ 2400382582 CSC_Tcell_72_54 255 "Invalid" ;
