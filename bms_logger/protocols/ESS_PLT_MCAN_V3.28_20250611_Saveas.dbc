VERSION ""

NS_ :

BS_:

BU_: MBMU PC SBMU IMM ETH DCDC LEMS

BO_ 2400382549 S2P_Detail_Tcell1__21: 8 SBMU
 SG_ CSC_T_No_21 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_21 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_21 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_21 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_21 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_21 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_21 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_21 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_21 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_21 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_21 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_21 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_21 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_21 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_21 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_21 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_21 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_21 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_21 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_21 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_21 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_21 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_21 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_21 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_21 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_21 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_21 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_21 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_21 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_21 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_21 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_21 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_21 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_21 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_21 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_21 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_21 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_21 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_21 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_21 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_21 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_21 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_21 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_21 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_21 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_21 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_21 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_21 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_21 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_21 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_21 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_21 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_21 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_21 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_21 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_21 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_21 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_21 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_21 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_21 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_21 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_21 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_21 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_21 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_21 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_21 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_21 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_21 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_21 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_21 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_21 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_21 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_21 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_21 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382550 S2P_Detail_Tcell1__22: 8 SBMU
 SG_ CSC_T_No_22 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_22 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_22 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_22 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_22 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_22 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_22 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_22 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_22 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_22 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_22 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_22 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_22 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_22 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_22 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_22 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_22 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_22 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_22 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_22 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_22 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_22 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_22 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_22 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_22 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_22 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_22 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_22 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_22 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_22 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_22 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_22 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_22 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_22 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_22 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_22 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_22 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_22 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_22 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_22 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_22 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_22 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_22 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_22 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_22 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_22 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_22 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_22 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_22 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_22 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_22 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_22 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_22 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_22 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_22 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_22 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_22 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_22 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_22 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_22 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_22 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_22 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_22 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_22 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_22 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_22 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_22 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_22 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_22 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_22 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_22 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_22 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_22 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_22 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382551 S2P_Detail_Tcell1__23: 8 SBMU
 SG_ CSC_T_No_23 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_23 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_23 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_23 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_23 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_23 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_23 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_23 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_23 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_23 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_23 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_23 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_23 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_23 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_23 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_23 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_23 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_23 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_23 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_23 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_23 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_23 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_23 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_23 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_23 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_23 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_23 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_23 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_23 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_23 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_23 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_23 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_23 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_23 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_23 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_23 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_23 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_23 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_23 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_23 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_23 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_23 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_23 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_23 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_23 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_23 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_23 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_23 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_23 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_23 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_23 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_23 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_23 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_23 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_23 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_23 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_23 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_23 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_23 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_23 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_23 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_23 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_23 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_23 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_23 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_23 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_23 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_23 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_23 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_23 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_23 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_23 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_23 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_23 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382552 S2P_Detail_Tcell1__24: 8 SBMU
 SG_ CSC_T_No_24 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_24 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_24 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_24 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_24 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_24 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_24 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_24 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_24 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_24 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_24 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_24 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_24 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_24 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_24 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_24 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_24 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_24 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_24 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_24 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_24 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_24 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_24 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_24 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_24 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_24 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_24 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_24 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_24 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_24 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_24 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_24 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_24 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_24 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_24 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_24 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_24 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_24 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_24 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_24 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_24 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_24 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_24 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_24 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_24 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_24 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_24 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_24 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_24 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_24 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_24 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_24 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_24 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_24 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_24 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_24 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_24 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_24 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_24 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_24 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_24 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_24 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_24 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_24 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_24 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_24 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_24 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_24 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_24 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_24 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_24 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_24 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_24 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_24 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382553 S2P_Detail_Tcell1__25: 8 SBMU
 SG_ CSC_T_No_25 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_25 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_25 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_25 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_25 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_25 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_25 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_25 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_25 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_25 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_25 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_25 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_25 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_25 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_25 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_25 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_25 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_25 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_25 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_25 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_25 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_25 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_25 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_25 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_25 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_25 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_25 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_25 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_25 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_25 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_25 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_25 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_25 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_25 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_25 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_25 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_25 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_25 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_25 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_25 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_25 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_25 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_25 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_25 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_25 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_25 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_25 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_25 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_25 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_25 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_25 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_25 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_25 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_25 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_25 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_25 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_25 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_25 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_25 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_25 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_25 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_25 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_25 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_25 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_25 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_25 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_25 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_25 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_25 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_25 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_25 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_25 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_25 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_25 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382554 S2P_Detail_Tcell1__26: 8 SBMU
 SG_ CSC_T_No_26 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_26 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_26 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_26 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_26 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_26 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_26 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_26 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_26 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_26 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_26 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_26 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_26 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_26 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_26 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_26 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_26 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_26 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_26 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_26 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_26 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_26 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_26 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_26 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_26 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_26 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_26 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_26 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_26 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_26 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_26 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_26 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_26 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_26 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_26 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_26 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_26 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_26 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_26 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_26 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_26 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_26 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_26 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_26 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_26 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_26 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_26 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_26 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_26 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_26 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_26 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_26 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_26 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_26 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_26 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_26 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_26 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_26 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_26 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_26 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_26 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_26 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_26 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_26 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_26 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_26 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_26 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_26 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_26 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_26 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_26 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_26 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_26 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_26 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382555 S2P_Detail_Tcell1__27: 8 SBMU
 SG_ CSC_T_No_27 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_27 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_27 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_27 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_27 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_27 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_27 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_27 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_27 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_27 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_27 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_27 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_27 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_27 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_27 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_27 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_27 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_27 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_27 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_27 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_27 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_27 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_27 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_27 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_27 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_27 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_27 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_27 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_27 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_27 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_27 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_27 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_27 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_27 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_27 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_27 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_27 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_27 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_27 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_27 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_27 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_27 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_27 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_27 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_27 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_27 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_27 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_27 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_27 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_27 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_27 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_27 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_27 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_27 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_27 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_27 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_27 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_27 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_27 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_27 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_27 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_27 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_27 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_27 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_27 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_27 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_27 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_27 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_27 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_27 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_27 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_27 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_27 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_27 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382556 S2P_Detail_Tcell1__28: 8 SBMU
 SG_ CSC_T_No_28 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_28 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_28 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_28 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_28 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_28 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_28 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_28 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_28 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_28 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_28 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_28 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_28 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_28 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_28 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_28 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_28 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_28 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_28 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_28 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_28 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_28 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_28 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_28 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_28 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_28 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_28 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_28 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_28 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_28 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_28 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_28 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_28 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_28 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_28 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_28 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_28 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_28 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_28 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_28 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_28 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_28 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_28 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_28 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_28 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_28 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_28 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_28 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_28 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_28 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_28 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_28 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_28 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_28 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_28 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_28 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_28 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_28 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_28 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_28 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_28 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_28 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_28 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_28 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_28 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_28 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_28 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_28 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_28 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_28 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_28 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_28 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_28 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_28 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382557 S2P_Detail_Tcell1__29: 8 SBMU
 SG_ CSC_T_No_29 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_29 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_29 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_29 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_29 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_29 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_29 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_29 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_29 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_29 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_29 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_29 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_29 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_29 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_29 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_29 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_29 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_29 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_29 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_29 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_29 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_29 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_29 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_29 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_29 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_29 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_29 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_29 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_29 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_29 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_29 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_29 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_29 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_29 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_29 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_29 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_29 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_29 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_29 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_29 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_29 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_29 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_29 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_29 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_29 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_29 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_29 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_29 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_29 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_29 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_29 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_29 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_29 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_29 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_29 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_29 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_29 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_29 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_29 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_29 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_29 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_29 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_29 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_29 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_29 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_29 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_29 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_29 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_29 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_29 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_29 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_29 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_29 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_29 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382558 S2P_Detail_Tcell1__30: 8 SBMU
 SG_ CSC_T_No_30 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_30 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_30 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_30 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_30 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_30 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_30 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_30 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_30 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_30 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_30 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_30 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_30 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_30 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_30 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_30 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_30 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_30 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_30 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_30 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_30 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_30 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_30 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_30 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_30 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_30 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_30 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_30 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_30 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_30 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_30 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_30 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_30 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_30 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_30 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_30 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_30 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_30 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_30 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_30 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_30 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_30 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_30 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_30 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_30 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_30 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_30 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_30 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_30 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_30 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_30 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_30 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_30 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_30 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_30 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_30 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_30 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_30 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_30 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_30 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_30 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_30 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_30 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_30 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_30 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_30 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_30 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_30 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_30 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_30 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_30 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_30 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_30 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_30 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382559 S2P_Detail_Tcell1__31: 8 SBMU
 SG_ CSC_T_No_31 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_31 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_31 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_31 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_31 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_31 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_31 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_31 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_31 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_31 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_31 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_31 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_31 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_31 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_31 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_31 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_31 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_31 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_31 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_31 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_31 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_31 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_31 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_31 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_31 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_31 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_31 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_31 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_31 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_31 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_31 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_31 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_31 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_31 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_31 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_31 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_31 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_31 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_31 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_31 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_31 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_31 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_31 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_31 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_31 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_31 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_31 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_31 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_31 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_31 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_31 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_31 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_31 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_31 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_31 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_31 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_31 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_31 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_31 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_31 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_31 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_31 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_31 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_31 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_31 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_31 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_31 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_31 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_31 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_31 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_31 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_31 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_31 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_31 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382560 S2P_Detail_Tcell1__32: 8 SBMU
 SG_ CSC_T_No_32 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_32 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_32 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_32 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_32 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_32 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_32 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_32 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_32 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_32 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_32 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_32 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_32 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_32 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_32 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_32 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_32 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_32 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_32 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_32 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_32 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_32 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_32 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_32 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_32 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_32 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_32 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_32 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_32 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_32 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_32 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_32 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_32 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_32 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_32 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_32 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_32 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_32 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_32 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_32 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_32 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_32 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_32 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_32 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_32 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_32 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_32 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_32 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_32 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_32 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_32 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_32 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_32 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_32 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_32 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_32 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_32 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_32 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_32 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_32 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_32 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_32 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_32 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_32 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_32 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_32 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_32 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_32 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_32 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_32 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_32 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_32 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_32 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_32 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382561 S2P_Detail_Tcell1__33: 8 SBMU
 SG_ CSC_T_No_33 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_33 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_33 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_33 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_33 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_33 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_33 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_33 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_33 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_33 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_33 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_33 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_33 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_33 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_33 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_33 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_33 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_33 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_33 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_33 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_33 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_33 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_33 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_33 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_33 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_33 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_33 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_33 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_33 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_33 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_33 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_33 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_33 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_33 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_33 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_33 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_33 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_33 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_33 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_33 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_33 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_33 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_33 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_33 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_33 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_33 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_33 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_33 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_33 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_33 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_33 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_33 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_33 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_33 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_33 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_33 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_33 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_33 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_33 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_33 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_33 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_33 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_33 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_33 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_33 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_33 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_33 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_33 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_33 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_33 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_33 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_33 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_33 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_33 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382562 S2P_Detail_Tcell1__34: 8 SBMU
 SG_ CSC_T_No_34 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_34 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_34 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_34 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_34 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_34 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_34 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_34 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_34 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_34 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_34 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_34 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_34 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_34 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_34 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_34 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_34 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_34 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_34 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_34 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_34 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_34 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_34 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_34 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_34 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_34 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_34 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_34 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_34 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_34 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_34 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_34 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_34 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_34 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_34 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_34 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_34 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_34 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_34 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_34 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_34 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_34 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_34 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_34 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_34 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_34 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_34 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_34 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_34 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_34 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_34 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_34 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_34 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_34 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_34 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_34 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_34 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_34 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_34 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_34 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_34 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_34 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_34 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_34 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_34 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_34 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_34 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_34 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_34 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_34 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_34 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_34 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_34 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_34 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382563 S2P_Detail_Tcell1__35: 8 SBMU
 SG_ CSC_T_No_35 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_35 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_35 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_35 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_35 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_35 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_35 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_35 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_35 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_35 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_35 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_35 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_35 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_35 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_35 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_35 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_35 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_35 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_35 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_35 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_35 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_35 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_35 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_35 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_35 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_35 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_35 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_35 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_35 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_35 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_35 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_35 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_35 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_35 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_35 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_35 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_35 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_35 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_35 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_35 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_35 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_35 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_35 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_35 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_35 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_35 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_35 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_35 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_35 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_35 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_35 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_35 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_35 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_35 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_35 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_35 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_35 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_35 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_35 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_35 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_35 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_35 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_35 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_35 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_35 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_35 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_35 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_35 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_35 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_35 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_35 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_35 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_35 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_35 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382564 S2P_Detail_Tcell1__36: 8 SBMU
 SG_ CSC_T_No_36 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_36 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_36 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_36 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_36 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_36 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_36 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_36 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_36 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_36 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_36 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_36 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_36 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_36 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_36 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_36 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_36 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_36 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_36 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_36 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_36 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_36 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_36 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_36 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_36 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_36 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_36 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_36 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_36 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_36 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_36 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_36 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_36 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_36 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_36 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_36 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_36 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_36 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_36 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_36 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_36 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_36 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_36 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_36 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_36 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_36 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_36 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_36 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_36 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_36 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_36 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_36 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_36 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_36 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_36 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_36 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_36 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_36 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_36 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_36 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_36 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_36 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_36 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_36 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_36 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_36 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_36 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_36 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_36 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_36 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_36 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_36 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_36 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_36 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

BO_ 2400382565 S2P_Detail_Tcell1__37: 8 SBMU
 SG_ CSC_T_No_37 : 0|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_Frame_Index_37 M : 8|8@1+ (1,0) [0|255] ""  PC
 SG_ CSC_Tcell_01_37 m0 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_02_37 m0 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_03_37 m0 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_04_37 m0 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_05_37 m0 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_06_37 m0 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_07_37 m1 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_08_37 m1 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_09_37 m1 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_10_37 m1 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_11_37 m1 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_12_37 m1 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_13_37 m2 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_14_37 m2 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_15_37 m2 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_16_37 m2 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_17_37 m2 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_18_37 m2 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_19_37 m3 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_20_37 m3 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_21_37 m3 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_22_37 m3 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_23_37 m3 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_24_37 m3 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_25_37 m4 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_26_37 m4 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_27_37 m4 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_28_37 m4 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_29_37 m4 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_30_37 m4 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_31_37 m5 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_32_37 m5 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_33_37 m5 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_34_37 m5 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_35_37 m5 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_36_37 m5 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_37_37 m6 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_38_37 m6 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_39_37 m6 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_40_37 m6 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_41_37 m6 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_42_37 m6 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_43_37 m7 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_44_37 m7 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_45_37 m7 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_46_37 m7 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_47_37 m7 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_48_37 m7 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_49_37 m8 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_50_37 m8 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_51_37 m8 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_52_37 m8 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_53_37 m8 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_54_37 m8 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_55_37 m9 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_56_37 m9 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_57_37 m9 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_58_37 m9 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_59_37 m9 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_60_37 m9 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_61_37 m10 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_62_37 m10 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_63_37 m10 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_64_37 m10 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_65_37 m10 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_66_37 m10 : 56|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_67_37 m11 : 16|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_68_37 m11 : 24|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_69_37 m11 : 32|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_70_37 m11 : 40|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_71_37 m11 : 48|8@1+ (1,-50) [-50|205] "℃"  PC
 SG_ CSC_Tcell_72_37 m11 : 56|8@1+ (1,-50) [-50|205] "℃"  PC

CM_ SG_ 2400382549 CSC_T_No_21 "CSC号";
CM_ SG_ 2400382549 CSC_Tcell_Frame_Index_21 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382549 CSC_Tcell_01_21 "温度01";
CM_ SG_ 2400382549 CSC_Tcell_02_21 "温度02";
CM_ SG_ 2400382549 CSC_Tcell_03_21 "温度03";
CM_ SG_ 2400382549 CSC_Tcell_04_21 "温度04";
CM_ SG_ 2400382549 CSC_Tcell_05_21 "温度05";
CM_ SG_ 2400382549 CSC_Tcell_06_21 "温度06";
CM_ SG_ 2400382549 CSC_Tcell_07_21 "温度07";
CM_ SG_ 2400382549 CSC_Tcell_08_21 "温度08";
CM_ SG_ 2400382549 CSC_Tcell_09_21 "温度09";
CM_ SG_ 2400382549 CSC_Tcell_10_21 "温度10";
CM_ SG_ 2400382549 CSC_Tcell_11_21 "温度11";
CM_ SG_ 2400382549 CSC_Tcell_12_21 "温度12";
CM_ SG_ 2400382549 CSC_Tcell_13_21 "温度13";
CM_ SG_ 2400382549 CSC_Tcell_14_21 "温度14";
CM_ SG_ 2400382549 CSC_Tcell_15_21 "温度15";
CM_ SG_ 2400382549 CSC_Tcell_16_21 "温度16";
CM_ SG_ 2400382549 CSC_Tcell_17_21 "温度17";
CM_ SG_ 2400382549 CSC_Tcell_18_21 "温度18";
CM_ SG_ 2400382549 CSC_Tcell_19_21 "温度19";
CM_ SG_ 2400382549 CSC_Tcell_20_21 "温度20";
CM_ SG_ 2400382549 CSC_Tcell_21_21 "温度21";
CM_ SG_ 2400382549 CSC_Tcell_22_21 "温度22";
CM_ SG_ 2400382549 CSC_Tcell_23_21 "温度23";
CM_ SG_ 2400382549 CSC_Tcell_24_21 "温度24";
CM_ SG_ 2400382549 CSC_Tcell_25_21 "温度25";
CM_ SG_ 2400382549 CSC_Tcell_26_21 "温度26";
CM_ SG_ 2400382549 CSC_Tcell_27_21 "温度27";
CM_ SG_ 2400382549 CSC_Tcell_28_21 "温度28";
CM_ SG_ 2400382549 CSC_Tcell_29_21 "温度29";
CM_ SG_ 2400382549 CSC_Tcell_30_21 "温度30";
CM_ SG_ 2400382549 CSC_Tcell_31_21 "温度31";
CM_ SG_ 2400382549 CSC_Tcell_32_21 "温度32";
CM_ SG_ 2400382549 CSC_Tcell_33_21 "温度33";
CM_ SG_ 2400382549 CSC_Tcell_34_21 "温度34";
CM_ SG_ 2400382549 CSC_Tcell_35_21 "温度35";
CM_ SG_ 2400382549 CSC_Tcell_36_21 "温度36";
CM_ SG_ 2400382549 CSC_Tcell_37_21 "温度37";
CM_ SG_ 2400382549 CSC_Tcell_38_21 "温度38";
CM_ SG_ 2400382549 CSC_Tcell_39_21 "温度39";
CM_ SG_ 2400382549 CSC_Tcell_40_21 "温度40";
CM_ SG_ 2400382549 CSC_Tcell_41_21 "温度41";
CM_ SG_ 2400382549 CSC_Tcell_42_21 "温度42";
CM_ SG_ 2400382549 CSC_Tcell_43_21 "温度43";
CM_ SG_ 2400382549 CSC_Tcell_44_21 "温度44";
CM_ SG_ 2400382549 CSC_Tcell_45_21 "温度45";
CM_ SG_ 2400382549 CSC_Tcell_46_21 "温度46";
CM_ SG_ 2400382549 CSC_Tcell_47_21 "温度47";
CM_ SG_ 2400382549 CSC_Tcell_48_21 "温度48";
CM_ SG_ 2400382549 CSC_Tcell_49_21 "温度49";
CM_ SG_ 2400382549 CSC_Tcell_50_21 "温度50";
CM_ SG_ 2400382549 CSC_Tcell_51_21 "温度51";
CM_ SG_ 2400382549 CSC_Tcell_52_21 "温度52";
CM_ SG_ 2400382549 CSC_Tcell_53_21 "温度53";
CM_ SG_ 2400382549 CSC_Tcell_54_21 "温度54";
CM_ SG_ 2400382549 CSC_Tcell_55_21 "温度55";
CM_ SG_ 2400382549 CSC_Tcell_56_21 "温度56";
CM_ SG_ 2400382549 CSC_Tcell_57_21 "温度57";
CM_ SG_ 2400382549 CSC_Tcell_58_21 "温度58";
CM_ SG_ 2400382549 CSC_Tcell_59_21 "温度59";
CM_ SG_ 2400382549 CSC_Tcell_60_21 "温度60";
CM_ SG_ 2400382549 CSC_Tcell_61_21 "温度61";
CM_ SG_ 2400382549 CSC_Tcell_62_21 "温度62";
CM_ SG_ 2400382549 CSC_Tcell_63_21 "温度63";
CM_ SG_ 2400382549 CSC_Tcell_64_21 "温度64";
CM_ SG_ 2400382549 CSC_Tcell_65_21 "温度65";
CM_ SG_ 2400382549 CSC_Tcell_66_21 "温度66";
CM_ SG_ 2400382549 CSC_Tcell_67_21 "温度67";
CM_ SG_ 2400382549 CSC_Tcell_68_21 "温度68";
CM_ SG_ 2400382549 CSC_Tcell_69_21 "温度69";
CM_ SG_ 2400382549 CSC_Tcell_70_21 "温度70";
CM_ SG_ 2400382549 CSC_Tcell_71_21 "温度71";
CM_ SG_ 2400382549 CSC_Tcell_72_21 "温度72";
CM_ SG_ 2400382550 CSC_T_No_22 "CSC号";
CM_ SG_ 2400382550 CSC_Tcell_Frame_Index_22 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382550 CSC_Tcell_01_22 "温度01";
CM_ SG_ 2400382550 CSC_Tcell_02_22 "温度02";
CM_ SG_ 2400382550 CSC_Tcell_03_22 "温度03";
CM_ SG_ 2400382550 CSC_Tcell_04_22 "温度04";
CM_ SG_ 2400382550 CSC_Tcell_05_22 "温度05";
CM_ SG_ 2400382550 CSC_Tcell_06_22 "温度06";
CM_ SG_ 2400382550 CSC_Tcell_07_22 "温度07";
CM_ SG_ 2400382550 CSC_Tcell_08_22 "温度08";
CM_ SG_ 2400382550 CSC_Tcell_09_22 "温度09";
CM_ SG_ 2400382550 CSC_Tcell_10_22 "温度10";
CM_ SG_ 2400382550 CSC_Tcell_11_22 "温度11";
CM_ SG_ 2400382550 CSC_Tcell_12_22 "温度12";
CM_ SG_ 2400382550 CSC_Tcell_13_22 "温度13";
CM_ SG_ 2400382550 CSC_Tcell_14_22 "温度14";
CM_ SG_ 2400382550 CSC_Tcell_15_22 "温度15";
CM_ SG_ 2400382550 CSC_Tcell_16_22 "温度16";
CM_ SG_ 2400382550 CSC_Tcell_17_22 "温度17";
CM_ SG_ 2400382550 CSC_Tcell_18_22 "温度18";
CM_ SG_ 2400382550 CSC_Tcell_19_22 "温度19";
CM_ SG_ 2400382550 CSC_Tcell_20_22 "温度20";
CM_ SG_ 2400382550 CSC_Tcell_21_22 "温度21";
CM_ SG_ 2400382550 CSC_Tcell_22_22 "温度22";
CM_ SG_ 2400382550 CSC_Tcell_23_22 "温度23";
CM_ SG_ 2400382550 CSC_Tcell_24_22 "温度24";
CM_ SG_ 2400382550 CSC_Tcell_25_22 "温度25";
CM_ SG_ 2400382550 CSC_Tcell_26_22 "温度26";
CM_ SG_ 2400382550 CSC_Tcell_27_22 "温度27";
CM_ SG_ 2400382550 CSC_Tcell_28_22 "温度28";
CM_ SG_ 2400382550 CSC_Tcell_29_22 "温度29";
CM_ SG_ 2400382550 CSC_Tcell_30_22 "温度30";
CM_ SG_ 2400382550 CSC_Tcell_31_22 "温度31";
CM_ SG_ 2400382550 CSC_Tcell_32_22 "温度32";
CM_ SG_ 2400382550 CSC_Tcell_33_22 "温度33";
CM_ SG_ 2400382550 CSC_Tcell_34_22 "温度34";
CM_ SG_ 2400382550 CSC_Tcell_35_22 "温度35";
CM_ SG_ 2400382550 CSC_Tcell_36_22 "温度36";
CM_ SG_ 2400382550 CSC_Tcell_37_22 "温度37";
CM_ SG_ 2400382550 CSC_Tcell_38_22 "温度38";
CM_ SG_ 2400382550 CSC_Tcell_39_22 "温度39";
CM_ SG_ 2400382550 CSC_Tcell_40_22 "温度40";
CM_ SG_ 2400382550 CSC_Tcell_41_22 "温度41";
CM_ SG_ 2400382550 CSC_Tcell_42_22 "温度42";
CM_ SG_ 2400382550 CSC_Tcell_43_22 "温度43";
CM_ SG_ 2400382550 CSC_Tcell_44_22 "温度44";
CM_ SG_ 2400382550 CSC_Tcell_45_22 "温度45";
CM_ SG_ 2400382550 CSC_Tcell_46_22 "温度46";
CM_ SG_ 2400382550 CSC_Tcell_47_22 "温度47";
CM_ SG_ 2400382550 CSC_Tcell_48_22 "温度48";
CM_ SG_ 2400382550 CSC_Tcell_49_22 "温度49";
CM_ SG_ 2400382550 CSC_Tcell_50_22 "温度50";
CM_ SG_ 2400382550 CSC_Tcell_51_22 "温度51";
CM_ SG_ 2400382550 CSC_Tcell_52_22 "温度52";
CM_ SG_ 2400382550 CSC_Tcell_53_22 "温度53";
CM_ SG_ 2400382550 CSC_Tcell_54_22 "温度54";
CM_ SG_ 2400382550 CSC_Tcell_55_22 "温度55";
CM_ SG_ 2400382550 CSC_Tcell_56_22 "温度56";
CM_ SG_ 2400382550 CSC_Tcell_57_22 "温度57";
CM_ SG_ 2400382550 CSC_Tcell_58_22 "温度58";
CM_ SG_ 2400382550 CSC_Tcell_59_22 "温度59";
CM_ SG_ 2400382550 CSC_Tcell_60_22 "温度60";
CM_ SG_ 2400382550 CSC_Tcell_61_22 "温度61";
CM_ SG_ 2400382550 CSC_Tcell_62_22 "温度62";
CM_ SG_ 2400382550 CSC_Tcell_63_22 "温度63";
CM_ SG_ 2400382550 CSC_Tcell_64_22 "温度64";
CM_ SG_ 2400382550 CSC_Tcell_65_22 "温度65";
CM_ SG_ 2400382550 CSC_Tcell_66_22 "温度66";
CM_ SG_ 2400382550 CSC_Tcell_67_22 "温度67";
CM_ SG_ 2400382550 CSC_Tcell_68_22 "温度68";
CM_ SG_ 2400382550 CSC_Tcell_69_22 "温度69";
CM_ SG_ 2400382550 CSC_Tcell_70_22 "温度70";
CM_ SG_ 2400382550 CSC_Tcell_71_22 "温度71";
CM_ SG_ 2400382550 CSC_Tcell_72_22 "温度72";
CM_ SG_ 2400382551 CSC_T_No_23 "CSC号";
CM_ SG_ 2400382551 CSC_Tcell_Frame_Index_23 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382551 CSC_Tcell_01_23 "温度01";
CM_ SG_ 2400382551 CSC_Tcell_02_23 "温度02";
CM_ SG_ 2400382551 CSC_Tcell_03_23 "温度03";
CM_ SG_ 2400382551 CSC_Tcell_04_23 "温度04";
CM_ SG_ 2400382551 CSC_Tcell_05_23 "温度05";
CM_ SG_ 2400382551 CSC_Tcell_06_23 "温度06";
CM_ SG_ 2400382551 CSC_Tcell_07_23 "温度07";
CM_ SG_ 2400382551 CSC_Tcell_08_23 "温度08";
CM_ SG_ 2400382551 CSC_Tcell_09_23 "温度09";
CM_ SG_ 2400382551 CSC_Tcell_10_23 "温度10";
CM_ SG_ 2400382551 CSC_Tcell_11_23 "温度11";
CM_ SG_ 2400382551 CSC_Tcell_12_23 "温度12";
CM_ SG_ 2400382551 CSC_Tcell_13_23 "温度13";
CM_ SG_ 2400382551 CSC_Tcell_14_23 "温度14";
CM_ SG_ 2400382551 CSC_Tcell_15_23 "温度15";
CM_ SG_ 2400382551 CSC_Tcell_16_23 "温度16";
CM_ SG_ 2400382551 CSC_Tcell_17_23 "温度17";
CM_ SG_ 2400382551 CSC_Tcell_18_23 "温度18";
CM_ SG_ 2400382551 CSC_Tcell_19_23 "温度19";
CM_ SG_ 2400382551 CSC_Tcell_20_23 "温度20";
CM_ SG_ 2400382551 CSC_Tcell_21_23 "温度21";
CM_ SG_ 2400382551 CSC_Tcell_22_23 "温度22";
CM_ SG_ 2400382551 CSC_Tcell_23_23 "温度23";
CM_ SG_ 2400382551 CSC_Tcell_24_23 "温度24";
CM_ SG_ 2400382551 CSC_Tcell_25_23 "温度25";
CM_ SG_ 2400382551 CSC_Tcell_26_23 "温度26";
CM_ SG_ 2400382551 CSC_Tcell_27_23 "温度27";
CM_ SG_ 2400382551 CSC_Tcell_28_23 "温度28";
CM_ SG_ 2400382551 CSC_Tcell_29_23 "温度29";
CM_ SG_ 2400382551 CSC_Tcell_30_23 "温度30";
CM_ SG_ 2400382551 CSC_Tcell_31_23 "温度31";
CM_ SG_ 2400382551 CSC_Tcell_32_23 "温度32";
CM_ SG_ 2400382551 CSC_Tcell_33_23 "温度33";
CM_ SG_ 2400382551 CSC_Tcell_34_23 "温度34";
CM_ SG_ 2400382551 CSC_Tcell_35_23 "温度35";
CM_ SG_ 2400382551 CSC_Tcell_36_23 "温度36";
CM_ SG_ 2400382551 CSC_Tcell_37_23 "温度37";
CM_ SG_ 2400382551 CSC_Tcell_38_23 "温度38";
CM_ SG_ 2400382551 CSC_Tcell_39_23 "温度39";
CM_ SG_ 2400382551 CSC_Tcell_40_23 "温度40";
CM_ SG_ 2400382551 CSC_Tcell_41_23 "温度41";
CM_ SG_ 2400382551 CSC_Tcell_42_23 "温度42";
CM_ SG_ 2400382551 CSC_Tcell_43_23 "温度43";
CM_ SG_ 2400382551 CSC_Tcell_44_23 "温度44";
CM_ SG_ 2400382551 CSC_Tcell_45_23 "温度45";
CM_ SG_ 2400382551 CSC_Tcell_46_23 "温度46";
CM_ SG_ 2400382551 CSC_Tcell_47_23 "温度47";
CM_ SG_ 2400382551 CSC_Tcell_48_23 "温度48";
CM_ SG_ 2400382551 CSC_Tcell_49_23 "温度49";
CM_ SG_ 2400382551 CSC_Tcell_50_23 "温度50";
CM_ SG_ 2400382551 CSC_Tcell_51_23 "温度51";
CM_ SG_ 2400382551 CSC_Tcell_52_23 "温度52";
CM_ SG_ 2400382551 CSC_Tcell_53_23 "温度53";
CM_ SG_ 2400382551 CSC_Tcell_54_23 "温度54";
CM_ SG_ 2400382551 CSC_Tcell_55_23 "温度55";
CM_ SG_ 2400382551 CSC_Tcell_56_23 "温度56";
CM_ SG_ 2400382551 CSC_Tcell_57_23 "温度57";
CM_ SG_ 2400382551 CSC_Tcell_58_23 "温度58";
CM_ SG_ 2400382551 CSC_Tcell_59_23 "温度59";
CM_ SG_ 2400382551 CSC_Tcell_60_23 "温度60";
CM_ SG_ 2400382551 CSC_Tcell_61_23 "温度61";
CM_ SG_ 2400382551 CSC_Tcell_62_23 "温度62";
CM_ SG_ 2400382551 CSC_Tcell_63_23 "温度63";
CM_ SG_ 2400382551 CSC_Tcell_64_23 "温度64";
CM_ SG_ 2400382551 CSC_Tcell_65_23 "温度65";
CM_ SG_ 2400382551 CSC_Tcell_66_23 "温度66";
CM_ SG_ 2400382551 CSC_Tcell_67_23 "温度67";
CM_ SG_ 2400382551 CSC_Tcell_68_23 "温度68";
CM_ SG_ 2400382551 CSC_Tcell_69_23 "温度69";
CM_ SG_ 2400382551 CSC_Tcell_70_23 "温度70";
CM_ SG_ 2400382551 CSC_Tcell_71_23 "温度71";
CM_ SG_ 2400382551 CSC_Tcell_72_23 "温度72";
CM_ SG_ 2400382552 CSC_T_No_24 "CSC号";
CM_ SG_ 2400382552 CSC_Tcell_Frame_Index_24 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382552 CSC_Tcell_01_24 "温度01";
CM_ SG_ 2400382552 CSC_Tcell_02_24 "温度02";
CM_ SG_ 2400382552 CSC_Tcell_03_24 "温度03";
CM_ SG_ 2400382552 CSC_Tcell_04_24 "温度04";
CM_ SG_ 2400382552 CSC_Tcell_05_24 "温度05";
CM_ SG_ 2400382552 CSC_Tcell_06_24 "温度06";
CM_ SG_ 2400382552 CSC_Tcell_07_24 "温度07";
CM_ SG_ 2400382552 CSC_Tcell_08_24 "温度08";
CM_ SG_ 2400382552 CSC_Tcell_09_24 "温度09";
CM_ SG_ 2400382552 CSC_Tcell_10_24 "温度10";
CM_ SG_ 2400382552 CSC_Tcell_11_24 "温度11";
CM_ SG_ 2400382552 CSC_Tcell_12_24 "温度12";
CM_ SG_ 2400382552 CSC_Tcell_13_24 "温度13";
CM_ SG_ 2400382552 CSC_Tcell_14_24 "温度14";
CM_ SG_ 2400382552 CSC_Tcell_15_24 "温度15";
CM_ SG_ 2400382552 CSC_Tcell_16_24 "温度16";
CM_ SG_ 2400382552 CSC_Tcell_17_24 "温度17";
CM_ SG_ 2400382552 CSC_Tcell_18_24 "温度18";
CM_ SG_ 2400382552 CSC_Tcell_19_24 "温度19";
CM_ SG_ 2400382552 CSC_Tcell_20_24 "温度20";
CM_ SG_ 2400382552 CSC_Tcell_21_24 "温度21";
CM_ SG_ 2400382552 CSC_Tcell_22_24 "温度22";
CM_ SG_ 2400382552 CSC_Tcell_23_24 "温度23";
CM_ SG_ 2400382552 CSC_Tcell_24_24 "温度24";
CM_ SG_ 2400382552 CSC_Tcell_25_24 "温度25";
CM_ SG_ 2400382552 CSC_Tcell_26_24 "温度26";
CM_ SG_ 2400382552 CSC_Tcell_27_24 "温度27";
CM_ SG_ 2400382552 CSC_Tcell_28_24 "温度28";
CM_ SG_ 2400382552 CSC_Tcell_29_24 "温度29";
CM_ SG_ 2400382552 CSC_Tcell_30_24 "温度30";
CM_ SG_ 2400382552 CSC_Tcell_31_24 "温度31";
CM_ SG_ 2400382552 CSC_Tcell_32_24 "温度32";
CM_ SG_ 2400382552 CSC_Tcell_33_24 "温度33";
CM_ SG_ 2400382552 CSC_Tcell_34_24 "温度34";
CM_ SG_ 2400382552 CSC_Tcell_35_24 "温度35";
CM_ SG_ 2400382552 CSC_Tcell_36_24 "温度36";
CM_ SG_ 2400382552 CSC_Tcell_37_24 "温度37";
CM_ SG_ 2400382552 CSC_Tcell_38_24 "温度38";
CM_ SG_ 2400382552 CSC_Tcell_39_24 "温度39";
CM_ SG_ 2400382552 CSC_Tcell_40_24 "温度40";
CM_ SG_ 2400382552 CSC_Tcell_41_24 "温度41";
CM_ SG_ 2400382552 CSC_Tcell_42_24 "温度42";
CM_ SG_ 2400382552 CSC_Tcell_43_24 "温度43";
CM_ SG_ 2400382552 CSC_Tcell_44_24 "温度44";
CM_ SG_ 2400382552 CSC_Tcell_45_24 "温度45";
CM_ SG_ 2400382552 CSC_Tcell_46_24 "温度46";
CM_ SG_ 2400382552 CSC_Tcell_47_24 "温度47";
CM_ SG_ 2400382552 CSC_Tcell_48_24 "温度48";
CM_ SG_ 2400382552 CSC_Tcell_49_24 "温度49";
CM_ SG_ 2400382552 CSC_Tcell_50_24 "温度50";
CM_ SG_ 2400382552 CSC_Tcell_51_24 "温度51";
CM_ SG_ 2400382552 CSC_Tcell_52_24 "温度52";
CM_ SG_ 2400382552 CSC_Tcell_53_24 "温度53";
CM_ SG_ 2400382552 CSC_Tcell_54_24 "温度54";
CM_ SG_ 2400382552 CSC_Tcell_55_24 "温度55";
CM_ SG_ 2400382552 CSC_Tcell_56_24 "温度56";
CM_ SG_ 2400382552 CSC_Tcell_57_24 "温度57";
CM_ SG_ 2400382552 CSC_Tcell_58_24 "温度58";
CM_ SG_ 2400382552 CSC_Tcell_59_24 "温度59";
CM_ SG_ 2400382552 CSC_Tcell_60_24 "温度60";
CM_ SG_ 2400382552 CSC_Tcell_61_24 "温度61";
CM_ SG_ 2400382552 CSC_Tcell_62_24 "温度62";
CM_ SG_ 2400382552 CSC_Tcell_63_24 "温度63";
CM_ SG_ 2400382552 CSC_Tcell_64_24 "温度64";
CM_ SG_ 2400382552 CSC_Tcell_65_24 "温度65";
CM_ SG_ 2400382552 CSC_Tcell_66_24 "温度66";
CM_ SG_ 2400382552 CSC_Tcell_67_24 "温度67";
CM_ SG_ 2400382552 CSC_Tcell_68_24 "温度68";
CM_ SG_ 2400382552 CSC_Tcell_69_24 "温度69";
CM_ SG_ 2400382552 CSC_Tcell_70_24 "温度70";
CM_ SG_ 2400382552 CSC_Tcell_71_24 "温度71";
CM_ SG_ 2400382552 CSC_Tcell_72_24 "温度72";
CM_ SG_ 2400382553 CSC_T_No_25 "CSC号";
CM_ SG_ 2400382553 CSC_Tcell_Frame_Index_25 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382553 CSC_Tcell_01_25 "温度01";
CM_ SG_ 2400382553 CSC_Tcell_02_25 "温度02";
CM_ SG_ 2400382553 CSC_Tcell_03_25 "温度03";
CM_ SG_ 2400382553 CSC_Tcell_04_25 "温度04";
CM_ SG_ 2400382553 CSC_Tcell_05_25 "温度05";
CM_ SG_ 2400382553 CSC_Tcell_06_25 "温度06";
CM_ SG_ 2400382553 CSC_Tcell_07_25 "温度07";
CM_ SG_ 2400382553 CSC_Tcell_08_25 "温度08";
CM_ SG_ 2400382553 CSC_Tcell_09_25 "温度09";
CM_ SG_ 2400382553 CSC_Tcell_10_25 "温度10";
CM_ SG_ 2400382553 CSC_Tcell_11_25 "温度11";
CM_ SG_ 2400382553 CSC_Tcell_12_25 "温度12";
CM_ SG_ 2400382553 CSC_Tcell_13_25 "温度13";
CM_ SG_ 2400382553 CSC_Tcell_14_25 "温度14";
CM_ SG_ 2400382553 CSC_Tcell_15_25 "温度15";
CM_ SG_ 2400382553 CSC_Tcell_16_25 "温度16";
CM_ SG_ 2400382553 CSC_Tcell_17_25 "温度17";
CM_ SG_ 2400382553 CSC_Tcell_18_25 "温度18";
CM_ SG_ 2400382553 CSC_Tcell_19_25 "温度19";
CM_ SG_ 2400382553 CSC_Tcell_20_25 "温度20";
CM_ SG_ 2400382553 CSC_Tcell_21_25 "温度21";
CM_ SG_ 2400382553 CSC_Tcell_22_25 "温度22";
CM_ SG_ 2400382553 CSC_Tcell_23_25 "温度23";
CM_ SG_ 2400382553 CSC_Tcell_24_25 "温度24";
CM_ SG_ 2400382553 CSC_Tcell_25_25 "温度25";
CM_ SG_ 2400382553 CSC_Tcell_26_25 "温度26";
CM_ SG_ 2400382553 CSC_Tcell_27_25 "温度27";
CM_ SG_ 2400382553 CSC_Tcell_28_25 "温度28";
CM_ SG_ 2400382553 CSC_Tcell_29_25 "温度29";
CM_ SG_ 2400382553 CSC_Tcell_30_25 "温度30";
CM_ SG_ 2400382553 CSC_Tcell_31_25 "温度31";
CM_ SG_ 2400382553 CSC_Tcell_32_25 "温度32";
CM_ SG_ 2400382553 CSC_Tcell_33_25 "温度33";
CM_ SG_ 2400382553 CSC_Tcell_34_25 "温度34";
CM_ SG_ 2400382553 CSC_Tcell_35_25 "温度35";
CM_ SG_ 2400382553 CSC_Tcell_36_25 "温度36";
CM_ SG_ 2400382553 CSC_Tcell_37_25 "温度37";
CM_ SG_ 2400382553 CSC_Tcell_38_25 "温度38";
CM_ SG_ 2400382553 CSC_Tcell_39_25 "温度39";
CM_ SG_ 2400382553 CSC_Tcell_40_25 "温度40";
CM_ SG_ 2400382553 CSC_Tcell_41_25 "温度41";
CM_ SG_ 2400382553 CSC_Tcell_42_25 "温度42";
CM_ SG_ 2400382553 CSC_Tcell_43_25 "温度43";
CM_ SG_ 2400382553 CSC_Tcell_44_25 "温度44";
CM_ SG_ 2400382553 CSC_Tcell_45_25 "温度45";
CM_ SG_ 2400382553 CSC_Tcell_46_25 "温度46";
CM_ SG_ 2400382553 CSC_Tcell_47_25 "温度47";
CM_ SG_ 2400382553 CSC_Tcell_48_25 "温度48";
CM_ SG_ 2400382553 CSC_Tcell_49_25 "温度49";
CM_ SG_ 2400382553 CSC_Tcell_50_25 "温度50";
CM_ SG_ 2400382553 CSC_Tcell_51_25 "温度51";
CM_ SG_ 2400382553 CSC_Tcell_52_25 "温度52";
CM_ SG_ 2400382553 CSC_Tcell_53_25 "温度53";
CM_ SG_ 2400382553 CSC_Tcell_54_25 "温度54";
CM_ SG_ 2400382553 CSC_Tcell_55_25 "温度55";
CM_ SG_ 2400382553 CSC_Tcell_56_25 "温度56";
CM_ SG_ 2400382553 CSC_Tcell_57_25 "温度57";
CM_ SG_ 2400382553 CSC_Tcell_58_25 "温度58";
CM_ SG_ 2400382553 CSC_Tcell_59_25 "温度59";
CM_ SG_ 2400382553 CSC_Tcell_60_25 "温度60";
CM_ SG_ 2400382553 CSC_Tcell_61_25 "温度61";
CM_ SG_ 2400382553 CSC_Tcell_62_25 "温度62";
CM_ SG_ 2400382553 CSC_Tcell_63_25 "温度63";
CM_ SG_ 2400382553 CSC_Tcell_64_25 "温度64";
CM_ SG_ 2400382553 CSC_Tcell_65_25 "温度65";
CM_ SG_ 2400382553 CSC_Tcell_66_25 "温度66";
CM_ SG_ 2400382553 CSC_Tcell_67_25 "温度67";
CM_ SG_ 2400382553 CSC_Tcell_68_25 "温度68";
CM_ SG_ 2400382553 CSC_Tcell_69_25 "温度69";
CM_ SG_ 2400382553 CSC_Tcell_70_25 "温度70";
CM_ SG_ 2400382553 CSC_Tcell_71_25 "温度71";
CM_ SG_ 2400382553 CSC_Tcell_72_25 "温度72";
CM_ SG_ 2400382554 CSC_T_No_26 "CSC号";
CM_ SG_ 2400382554 CSC_Tcell_Frame_Index_26 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382554 CSC_Tcell_01_26 "温度01";
CM_ SG_ 2400382554 CSC_Tcell_02_26 "温度02";
CM_ SG_ 2400382554 CSC_Tcell_03_26 "温度03";
CM_ SG_ 2400382554 CSC_Tcell_04_26 "温度04";
CM_ SG_ 2400382554 CSC_Tcell_05_26 "温度05";
CM_ SG_ 2400382554 CSC_Tcell_06_26 "温度06";
CM_ SG_ 2400382554 CSC_Tcell_07_26 "温度07";
CM_ SG_ 2400382554 CSC_Tcell_08_26 "温度08";
CM_ SG_ 2400382554 CSC_Tcell_09_26 "温度09";
CM_ SG_ 2400382554 CSC_Tcell_10_26 "温度10";
CM_ SG_ 2400382554 CSC_Tcell_11_26 "温度11";
CM_ SG_ 2400382554 CSC_Tcell_12_26 "温度12";
CM_ SG_ 2400382554 CSC_Tcell_13_26 "温度13";
CM_ SG_ 2400382554 CSC_Tcell_14_26 "温度14";
CM_ SG_ 2400382554 CSC_Tcell_15_26 "温度15";
CM_ SG_ 2400382554 CSC_Tcell_16_26 "温度16";
CM_ SG_ 2400382554 CSC_Tcell_17_26 "温度17";
CM_ SG_ 2400382554 CSC_Tcell_18_26 "温度18";
CM_ SG_ 2400382554 CSC_Tcell_19_26 "温度19";
CM_ SG_ 2400382554 CSC_Tcell_20_26 "温度20";
CM_ SG_ 2400382554 CSC_Tcell_21_26 "温度21";
CM_ SG_ 2400382554 CSC_Tcell_22_26 "温度22";
CM_ SG_ 2400382554 CSC_Tcell_23_26 "温度23";
CM_ SG_ 2400382554 CSC_Tcell_24_26 "温度24";
CM_ SG_ 2400382554 CSC_Tcell_25_26 "温度25";
CM_ SG_ 2400382554 CSC_Tcell_26_26 "温度26";
CM_ SG_ 2400382554 CSC_Tcell_27_26 "温度27";
CM_ SG_ 2400382554 CSC_Tcell_28_26 "温度28";
CM_ SG_ 2400382554 CSC_Tcell_29_26 "温度29";
CM_ SG_ 2400382554 CSC_Tcell_30_26 "温度30";
CM_ SG_ 2400382554 CSC_Tcell_31_26 "温度31";
CM_ SG_ 2400382554 CSC_Tcell_32_26 "温度32";
CM_ SG_ 2400382554 CSC_Tcell_33_26 "温度33";
CM_ SG_ 2400382554 CSC_Tcell_34_26 "温度34";
CM_ SG_ 2400382554 CSC_Tcell_35_26 "温度35";
CM_ SG_ 2400382554 CSC_Tcell_36_26 "温度36";
CM_ SG_ 2400382554 CSC_Tcell_37_26 "温度37";
CM_ SG_ 2400382554 CSC_Tcell_38_26 "温度38";
CM_ SG_ 2400382554 CSC_Tcell_39_26 "温度39";
CM_ SG_ 2400382554 CSC_Tcell_40_26 "温度40";
CM_ SG_ 2400382554 CSC_Tcell_41_26 "温度41";
CM_ SG_ 2400382554 CSC_Tcell_42_26 "温度42";
CM_ SG_ 2400382554 CSC_Tcell_43_26 "温度43";
CM_ SG_ 2400382554 CSC_Tcell_44_26 "温度44";
CM_ SG_ 2400382554 CSC_Tcell_45_26 "温度45";
CM_ SG_ 2400382554 CSC_Tcell_46_26 "温度46";
CM_ SG_ 2400382554 CSC_Tcell_47_26 "温度47";
CM_ SG_ 2400382554 CSC_Tcell_48_26 "温度48";
CM_ SG_ 2400382554 CSC_Tcell_49_26 "温度49";
CM_ SG_ 2400382554 CSC_Tcell_50_26 "温度50";
CM_ SG_ 2400382554 CSC_Tcell_51_26 "温度51";
CM_ SG_ 2400382554 CSC_Tcell_52_26 "温度52";
CM_ SG_ 2400382554 CSC_Tcell_53_26 "温度53";
CM_ SG_ 2400382554 CSC_Tcell_54_26 "温度54";
CM_ SG_ 2400382554 CSC_Tcell_55_26 "温度55";
CM_ SG_ 2400382554 CSC_Tcell_56_26 "温度56";
CM_ SG_ 2400382554 CSC_Tcell_57_26 "温度57";
CM_ SG_ 2400382554 CSC_Tcell_58_26 "温度58";
CM_ SG_ 2400382554 CSC_Tcell_59_26 "温度59";
CM_ SG_ 2400382554 CSC_Tcell_60_26 "温度60";
CM_ SG_ 2400382554 CSC_Tcell_61_26 "温度61";
CM_ SG_ 2400382554 CSC_Tcell_62_26 "温度62";
CM_ SG_ 2400382554 CSC_Tcell_63_26 "温度63";
CM_ SG_ 2400382554 CSC_Tcell_64_26 "温度64";
CM_ SG_ 2400382554 CSC_Tcell_65_26 "温度65";
CM_ SG_ 2400382554 CSC_Tcell_66_26 "温度66";
CM_ SG_ 2400382554 CSC_Tcell_67_26 "温度67";
CM_ SG_ 2400382554 CSC_Tcell_68_26 "温度68";
CM_ SG_ 2400382554 CSC_Tcell_69_26 "温度69";
CM_ SG_ 2400382554 CSC_Tcell_70_26 "温度70";
CM_ SG_ 2400382554 CSC_Tcell_71_26 "温度71";
CM_ SG_ 2400382554 CSC_Tcell_72_26 "温度72";
CM_ SG_ 2400382555 CSC_T_No_27 "CSC号";
CM_ SG_ 2400382555 CSC_Tcell_Frame_Index_27 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382555 CSC_Tcell_01_27 "温度01";
CM_ SG_ 2400382555 CSC_Tcell_02_27 "温度02";
CM_ SG_ 2400382555 CSC_Tcell_03_27 "温度03";
CM_ SG_ 2400382555 CSC_Tcell_04_27 "温度04";
CM_ SG_ 2400382555 CSC_Tcell_05_27 "温度05";
CM_ SG_ 2400382555 CSC_Tcell_06_27 "温度06";
CM_ SG_ 2400382555 CSC_Tcell_07_27 "温度07";
CM_ SG_ 2400382555 CSC_Tcell_08_27 "温度08";
CM_ SG_ 2400382555 CSC_Tcell_09_27 "温度09";
CM_ SG_ 2400382555 CSC_Tcell_10_27 "温度10";
CM_ SG_ 2400382555 CSC_Tcell_11_27 "温度11";
CM_ SG_ 2400382555 CSC_Tcell_12_27 "温度12";
CM_ SG_ 2400382555 CSC_Tcell_13_27 "温度13";
CM_ SG_ 2400382555 CSC_Tcell_14_27 "温度14";
CM_ SG_ 2400382555 CSC_Tcell_15_27 "温度15";
CM_ SG_ 2400382555 CSC_Tcell_16_27 "温度16";
CM_ SG_ 2400382555 CSC_Tcell_17_27 "温度17";
CM_ SG_ 2400382555 CSC_Tcell_18_27 "温度18";
CM_ SG_ 2400382555 CSC_Tcell_19_27 "温度19";
CM_ SG_ 2400382555 CSC_Tcell_20_27 "温度20";
CM_ SG_ 2400382555 CSC_Tcell_21_27 "温度21";
CM_ SG_ 2400382555 CSC_Tcell_22_27 "温度22";
CM_ SG_ 2400382555 CSC_Tcell_23_27 "温度23";
CM_ SG_ 2400382555 CSC_Tcell_24_27 "温度24";
CM_ SG_ 2400382555 CSC_Tcell_25_27 "温度25";
CM_ SG_ 2400382555 CSC_Tcell_26_27 "温度26";
CM_ SG_ 2400382555 CSC_Tcell_27_27 "温度27";
CM_ SG_ 2400382555 CSC_Tcell_28_27 "温度28";
CM_ SG_ 2400382555 CSC_Tcell_29_27 "温度29";
CM_ SG_ 2400382555 CSC_Tcell_30_27 "温度30";
CM_ SG_ 2400382555 CSC_Tcell_31_27 "温度31";
CM_ SG_ 2400382555 CSC_Tcell_32_27 "温度32";
CM_ SG_ 2400382555 CSC_Tcell_33_27 "温度33";
CM_ SG_ 2400382555 CSC_Tcell_34_27 "温度34";
CM_ SG_ 2400382555 CSC_Tcell_35_27 "温度35";
CM_ SG_ 2400382555 CSC_Tcell_36_27 "温度36";
CM_ SG_ 2400382555 CSC_Tcell_37_27 "温度37";
CM_ SG_ 2400382555 CSC_Tcell_38_27 "温度38";
CM_ SG_ 2400382555 CSC_Tcell_39_27 "温度39";
CM_ SG_ 2400382555 CSC_Tcell_40_27 "温度40";
CM_ SG_ 2400382555 CSC_Tcell_41_27 "温度41";
CM_ SG_ 2400382555 CSC_Tcell_42_27 "温度42";
CM_ SG_ 2400382555 CSC_Tcell_43_27 "温度43";
CM_ SG_ 2400382555 CSC_Tcell_44_27 "温度44";
CM_ SG_ 2400382555 CSC_Tcell_45_27 "温度45";
CM_ SG_ 2400382555 CSC_Tcell_46_27 "温度46";
CM_ SG_ 2400382555 CSC_Tcell_47_27 "温度47";
CM_ SG_ 2400382555 CSC_Tcell_48_27 "温度48";
CM_ SG_ 2400382555 CSC_Tcell_49_27 "温度49";
CM_ SG_ 2400382555 CSC_Tcell_50_27 "温度50";
CM_ SG_ 2400382555 CSC_Tcell_51_27 "温度51";
CM_ SG_ 2400382555 CSC_Tcell_52_27 "温度52";
CM_ SG_ 2400382555 CSC_Tcell_53_27 "温度53";
CM_ SG_ 2400382555 CSC_Tcell_54_27 "温度54";
CM_ SG_ 2400382555 CSC_Tcell_55_27 "温度55";
CM_ SG_ 2400382555 CSC_Tcell_56_27 "温度56";
CM_ SG_ 2400382555 CSC_Tcell_57_27 "温度57";
CM_ SG_ 2400382555 CSC_Tcell_58_27 "温度58";
CM_ SG_ 2400382555 CSC_Tcell_59_27 "温度59";
CM_ SG_ 2400382555 CSC_Tcell_60_27 "温度60";
CM_ SG_ 2400382555 CSC_Tcell_61_27 "温度61";
CM_ SG_ 2400382555 CSC_Tcell_62_27 "温度62";
CM_ SG_ 2400382555 CSC_Tcell_63_27 "温度63";
CM_ SG_ 2400382555 CSC_Tcell_64_27 "温度64";
CM_ SG_ 2400382555 CSC_Tcell_65_27 "温度65";
CM_ SG_ 2400382555 CSC_Tcell_66_27 "温度66";
CM_ SG_ 2400382555 CSC_Tcell_67_27 "温度67";
CM_ SG_ 2400382555 CSC_Tcell_68_27 "温度68";
CM_ SG_ 2400382555 CSC_Tcell_69_27 "温度69";
CM_ SG_ 2400382555 CSC_Tcell_70_27 "温度70";
CM_ SG_ 2400382555 CSC_Tcell_71_27 "温度71";
CM_ SG_ 2400382555 CSC_Tcell_72_27 "温度72";
CM_ SG_ 2400382556 CSC_T_No_28 "CSC号";
CM_ SG_ 2400382556 CSC_Tcell_Frame_Index_28 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382556 CSC_Tcell_01_28 "温度01";
CM_ SG_ 2400382556 CSC_Tcell_02_28 "温度02";
CM_ SG_ 2400382556 CSC_Tcell_03_28 "温度03";
CM_ SG_ 2400382556 CSC_Tcell_04_28 "温度04";
CM_ SG_ 2400382556 CSC_Tcell_05_28 "温度05";
CM_ SG_ 2400382556 CSC_Tcell_06_28 "温度06";
CM_ SG_ 2400382556 CSC_Tcell_07_28 "温度07";
CM_ SG_ 2400382556 CSC_Tcell_08_28 "温度08";
CM_ SG_ 2400382556 CSC_Tcell_09_28 "温度09";
CM_ SG_ 2400382556 CSC_Tcell_10_28 "温度10";
CM_ SG_ 2400382556 CSC_Tcell_11_28 "温度11";
CM_ SG_ 2400382556 CSC_Tcell_12_28 "温度12";
CM_ SG_ 2400382556 CSC_Tcell_13_28 "温度13";
CM_ SG_ 2400382556 CSC_Tcell_14_28 "温度14";
CM_ SG_ 2400382556 CSC_Tcell_15_28 "温度15";
CM_ SG_ 2400382556 CSC_Tcell_16_28 "温度16";
CM_ SG_ 2400382556 CSC_Tcell_17_28 "温度17";
CM_ SG_ 2400382556 CSC_Tcell_18_28 "温度18";
CM_ SG_ 2400382556 CSC_Tcell_19_28 "温度19";
CM_ SG_ 2400382556 CSC_Tcell_20_28 "温度20";
CM_ SG_ 2400382556 CSC_Tcell_21_28 "温度21";
CM_ SG_ 2400382556 CSC_Tcell_22_28 "温度22";
CM_ SG_ 2400382556 CSC_Tcell_23_28 "温度23";
CM_ SG_ 2400382556 CSC_Tcell_24_28 "温度24";
CM_ SG_ 2400382556 CSC_Tcell_25_28 "温度25";
CM_ SG_ 2400382556 CSC_Tcell_26_28 "温度26";
CM_ SG_ 2400382556 CSC_Tcell_27_28 "温度27";
CM_ SG_ 2400382556 CSC_Tcell_28_28 "温度28";
CM_ SG_ 2400382556 CSC_Tcell_29_28 "温度29";
CM_ SG_ 2400382556 CSC_Tcell_30_28 "温度30";
CM_ SG_ 2400382556 CSC_Tcell_31_28 "温度31";
CM_ SG_ 2400382556 CSC_Tcell_32_28 "温度32";
CM_ SG_ 2400382556 CSC_Tcell_33_28 "温度33";
CM_ SG_ 2400382556 CSC_Tcell_34_28 "温度34";
CM_ SG_ 2400382556 CSC_Tcell_35_28 "温度35";
CM_ SG_ 2400382556 CSC_Tcell_36_28 "温度36";
CM_ SG_ 2400382556 CSC_Tcell_37_28 "温度37";
CM_ SG_ 2400382556 CSC_Tcell_38_28 "温度38";
CM_ SG_ 2400382556 CSC_Tcell_39_28 "温度39";
CM_ SG_ 2400382556 CSC_Tcell_40_28 "温度40";
CM_ SG_ 2400382556 CSC_Tcell_41_28 "温度41";
CM_ SG_ 2400382556 CSC_Tcell_42_28 "温度42";
CM_ SG_ 2400382556 CSC_Tcell_43_28 "温度43";
CM_ SG_ 2400382556 CSC_Tcell_44_28 "温度44";
CM_ SG_ 2400382556 CSC_Tcell_45_28 "温度45";
CM_ SG_ 2400382556 CSC_Tcell_46_28 "温度46";
CM_ SG_ 2400382556 CSC_Tcell_47_28 "温度47";
CM_ SG_ 2400382556 CSC_Tcell_48_28 "温度48";
CM_ SG_ 2400382556 CSC_Tcell_49_28 "温度49";
CM_ SG_ 2400382556 CSC_Tcell_50_28 "温度50";
CM_ SG_ 2400382556 CSC_Tcell_51_28 "温度51";
CM_ SG_ 2400382556 CSC_Tcell_52_28 "温度52";
CM_ SG_ 2400382556 CSC_Tcell_53_28 "温度53";
CM_ SG_ 2400382556 CSC_Tcell_54_28 "温度54";
CM_ SG_ 2400382556 CSC_Tcell_55_28 "温度55";
CM_ SG_ 2400382556 CSC_Tcell_56_28 "温度56";
CM_ SG_ 2400382556 CSC_Tcell_57_28 "温度57";
CM_ SG_ 2400382556 CSC_Tcell_58_28 "温度58";
CM_ SG_ 2400382556 CSC_Tcell_59_28 "温度59";
CM_ SG_ 2400382556 CSC_Tcell_60_28 "温度60";
CM_ SG_ 2400382556 CSC_Tcell_61_28 "温度61";
CM_ SG_ 2400382556 CSC_Tcell_62_28 "温度62";
CM_ SG_ 2400382556 CSC_Tcell_63_28 "温度63";
CM_ SG_ 2400382556 CSC_Tcell_64_28 "温度64";
CM_ SG_ 2400382556 CSC_Tcell_65_28 "温度65";
CM_ SG_ 2400382556 CSC_Tcell_66_28 "温度66";
CM_ SG_ 2400382556 CSC_Tcell_67_28 "温度67";
CM_ SG_ 2400382556 CSC_Tcell_68_28 "温度68";
CM_ SG_ 2400382556 CSC_Tcell_69_28 "温度69";
CM_ SG_ 2400382556 CSC_Tcell_70_28 "温度70";
CM_ SG_ 2400382556 CSC_Tcell_71_28 "温度71";
CM_ SG_ 2400382556 CSC_Tcell_72_28 "温度72";
CM_ SG_ 2400382557 CSC_T_No_29 "CSC号";
CM_ SG_ 2400382557 CSC_Tcell_Frame_Index_29 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382557 CSC_Tcell_01_29 "温度01";
CM_ SG_ 2400382557 CSC_Tcell_02_29 "温度02";
CM_ SG_ 2400382557 CSC_Tcell_03_29 "温度03";
CM_ SG_ 2400382557 CSC_Tcell_04_29 "温度04";
CM_ SG_ 2400382557 CSC_Tcell_05_29 "温度05";
CM_ SG_ 2400382557 CSC_Tcell_06_29 "温度06";
CM_ SG_ 2400382557 CSC_Tcell_07_29 "温度07";
CM_ SG_ 2400382557 CSC_Tcell_08_29 "温度08";
CM_ SG_ 2400382557 CSC_Tcell_09_29 "温度09";
CM_ SG_ 2400382557 CSC_Tcell_10_29 "温度10";
CM_ SG_ 2400382557 CSC_Tcell_11_29 "温度11";
CM_ SG_ 2400382557 CSC_Tcell_12_29 "温度12";
CM_ SG_ 2400382557 CSC_Tcell_13_29 "温度13";
CM_ SG_ 2400382557 CSC_Tcell_14_29 "温度14";
CM_ SG_ 2400382557 CSC_Tcell_15_29 "温度15";
CM_ SG_ 2400382557 CSC_Tcell_16_29 "温度16";
CM_ SG_ 2400382557 CSC_Tcell_17_29 "温度17";
CM_ SG_ 2400382557 CSC_Tcell_18_29 "温度18";
CM_ SG_ 2400382557 CSC_Tcell_19_29 "温度19";
CM_ SG_ 2400382557 CSC_Tcell_20_29 "温度20";
CM_ SG_ 2400382557 CSC_Tcell_21_29 "温度21";
CM_ SG_ 2400382557 CSC_Tcell_22_29 "温度22";
CM_ SG_ 2400382557 CSC_Tcell_23_29 "温度23";
CM_ SG_ 2400382557 CSC_Tcell_24_29 "温度24";
CM_ SG_ 2400382557 CSC_Tcell_25_29 "温度25";
CM_ SG_ 2400382557 CSC_Tcell_26_29 "温度26";
CM_ SG_ 2400382557 CSC_Tcell_27_29 "温度27";
CM_ SG_ 2400382557 CSC_Tcell_28_29 "温度28";
CM_ SG_ 2400382557 CSC_Tcell_29_29 "温度29";
CM_ SG_ 2400382557 CSC_Tcell_30_29 "温度30";
CM_ SG_ 2400382557 CSC_Tcell_31_29 "温度31";
CM_ SG_ 2400382557 CSC_Tcell_32_29 "温度32";
CM_ SG_ 2400382557 CSC_Tcell_33_29 "温度33";
CM_ SG_ 2400382557 CSC_Tcell_34_29 "温度34";
CM_ SG_ 2400382557 CSC_Tcell_35_29 "温度35";
CM_ SG_ 2400382557 CSC_Tcell_36_29 "温度36";
CM_ SG_ 2400382557 CSC_Tcell_37_29 "温度37";
CM_ SG_ 2400382557 CSC_Tcell_38_29 "温度38";
CM_ SG_ 2400382557 CSC_Tcell_39_29 "温度39";
CM_ SG_ 2400382557 CSC_Tcell_40_29 "温度40";
CM_ SG_ 2400382557 CSC_Tcell_41_29 "温度41";
CM_ SG_ 2400382557 CSC_Tcell_42_29 "温度42";
CM_ SG_ 2400382557 CSC_Tcell_43_29 "温度43";
CM_ SG_ 2400382557 CSC_Tcell_44_29 "温度44";
CM_ SG_ 2400382557 CSC_Tcell_45_29 "温度45";
CM_ SG_ 2400382557 CSC_Tcell_46_29 "温度46";
CM_ SG_ 2400382557 CSC_Tcell_47_29 "温度47";
CM_ SG_ 2400382557 CSC_Tcell_48_29 "温度48";
CM_ SG_ 2400382557 CSC_Tcell_49_29 "温度49";
CM_ SG_ 2400382557 CSC_Tcell_50_29 "温度50";
CM_ SG_ 2400382557 CSC_Tcell_51_29 "温度51";
CM_ SG_ 2400382557 CSC_Tcell_52_29 "温度52";
CM_ SG_ 2400382557 CSC_Tcell_53_29 "温度53";
CM_ SG_ 2400382557 CSC_Tcell_54_29 "温度54";
CM_ SG_ 2400382557 CSC_Tcell_55_29 "温度55";
CM_ SG_ 2400382557 CSC_Tcell_56_29 "温度56";
CM_ SG_ 2400382557 CSC_Tcell_57_29 "温度57";
CM_ SG_ 2400382557 CSC_Tcell_58_29 "温度58";
CM_ SG_ 2400382557 CSC_Tcell_59_29 "温度59";
CM_ SG_ 2400382557 CSC_Tcell_60_29 "温度60";
CM_ SG_ 2400382557 CSC_Tcell_61_29 "温度61";
CM_ SG_ 2400382557 CSC_Tcell_62_29 "温度62";
CM_ SG_ 2400382557 CSC_Tcell_63_29 "温度63";
CM_ SG_ 2400382557 CSC_Tcell_64_29 "温度64";
CM_ SG_ 2400382557 CSC_Tcell_65_29 "温度65";
CM_ SG_ 2400382557 CSC_Tcell_66_29 "温度66";
CM_ SG_ 2400382557 CSC_Tcell_67_29 "温度67";
CM_ SG_ 2400382557 CSC_Tcell_68_29 "温度68";
CM_ SG_ 2400382557 CSC_Tcell_69_29 "温度69";
CM_ SG_ 2400382557 CSC_Tcell_70_29 "温度70";
CM_ SG_ 2400382557 CSC_Tcell_71_29 "温度71";
CM_ SG_ 2400382557 CSC_Tcell_72_29 "温度72";
CM_ SG_ 2400382558 CSC_T_No_30 "CSC号";
CM_ SG_ 2400382558 CSC_Tcell_Frame_Index_30 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382558 CSC_Tcell_01_30 "温度01";
CM_ SG_ 2400382558 CSC_Tcell_02_30 "温度02";
CM_ SG_ 2400382558 CSC_Tcell_03_30 "温度03";
CM_ SG_ 2400382558 CSC_Tcell_04_30 "温度04";
CM_ SG_ 2400382558 CSC_Tcell_05_30 "温度05";
CM_ SG_ 2400382558 CSC_Tcell_06_30 "温度06";
CM_ SG_ 2400382558 CSC_Tcell_07_30 "温度07";
CM_ SG_ 2400382558 CSC_Tcell_08_30 "温度08";
CM_ SG_ 2400382558 CSC_Tcell_09_30 "温度09";
CM_ SG_ 2400382558 CSC_Tcell_10_30 "温度10";
CM_ SG_ 2400382558 CSC_Tcell_11_30 "温度11";
CM_ SG_ 2400382558 CSC_Tcell_12_30 "温度12";
CM_ SG_ 2400382558 CSC_Tcell_13_30 "温度13";
CM_ SG_ 2400382558 CSC_Tcell_14_30 "温度14";
CM_ SG_ 2400382558 CSC_Tcell_15_30 "温度15";
CM_ SG_ 2400382558 CSC_Tcell_16_30 "温度16";
CM_ SG_ 2400382558 CSC_Tcell_17_30 "温度17";
CM_ SG_ 2400382558 CSC_Tcell_18_30 "温度18";
CM_ SG_ 2400382558 CSC_Tcell_19_30 "温度19";
CM_ SG_ 2400382558 CSC_Tcell_20_30 "温度20";
CM_ SG_ 2400382558 CSC_Tcell_21_30 "温度21";
CM_ SG_ 2400382558 CSC_Tcell_22_30 "温度22";
CM_ SG_ 2400382558 CSC_Tcell_23_30 "温度23";
CM_ SG_ 2400382558 CSC_Tcell_24_30 "温度24";
CM_ SG_ 2400382558 CSC_Tcell_25_30 "温度25";
CM_ SG_ 2400382558 CSC_Tcell_26_30 "温度26";
CM_ SG_ 2400382558 CSC_Tcell_27_30 "温度27";
CM_ SG_ 2400382558 CSC_Tcell_28_30 "温度28";
CM_ SG_ 2400382558 CSC_Tcell_29_30 "温度29";
CM_ SG_ 2400382558 CSC_Tcell_30_30 "温度30";
CM_ SG_ 2400382558 CSC_Tcell_31_30 "温度31";
CM_ SG_ 2400382558 CSC_Tcell_32_30 "温度32";
CM_ SG_ 2400382558 CSC_Tcell_33_30 "温度33";
CM_ SG_ 2400382558 CSC_Tcell_34_30 "温度34";
CM_ SG_ 2400382558 CSC_Tcell_35_30 "温度35";
CM_ SG_ 2400382558 CSC_Tcell_36_30 "温度36";
CM_ SG_ 2400382558 CSC_Tcell_37_30 "温度37";
CM_ SG_ 2400382558 CSC_Tcell_38_30 "温度38";
CM_ SG_ 2400382558 CSC_Tcell_39_30 "温度39";
CM_ SG_ 2400382558 CSC_Tcell_40_30 "温度40";
CM_ SG_ 2400382558 CSC_Tcell_41_30 "温度41";
CM_ SG_ 2400382558 CSC_Tcell_42_30 "温度42";
CM_ SG_ 2400382558 CSC_Tcell_43_30 "温度43";
CM_ SG_ 2400382558 CSC_Tcell_44_30 "温度44";
CM_ SG_ 2400382558 CSC_Tcell_45_30 "温度45";
CM_ SG_ 2400382558 CSC_Tcell_46_30 "温度46";
CM_ SG_ 2400382558 CSC_Tcell_47_30 "温度47";
CM_ SG_ 2400382558 CSC_Tcell_48_30 "温度48";
CM_ SG_ 2400382558 CSC_Tcell_49_30 "温度49";
CM_ SG_ 2400382558 CSC_Tcell_50_30 "温度50";
CM_ SG_ 2400382558 CSC_Tcell_51_30 "温度51";
CM_ SG_ 2400382558 CSC_Tcell_52_30 "温度52";
CM_ SG_ 2400382558 CSC_Tcell_53_30 "温度53";
CM_ SG_ 2400382558 CSC_Tcell_54_30 "温度54";
CM_ SG_ 2400382558 CSC_Tcell_55_30 "温度55";
CM_ SG_ 2400382558 CSC_Tcell_56_30 "温度56";
CM_ SG_ 2400382558 CSC_Tcell_57_30 "温度57";
CM_ SG_ 2400382558 CSC_Tcell_58_30 "温度58";
CM_ SG_ 2400382558 CSC_Tcell_59_30 "温度59";
CM_ SG_ 2400382558 CSC_Tcell_60_30 "温度60";
CM_ SG_ 2400382558 CSC_Tcell_61_30 "温度61";
CM_ SG_ 2400382558 CSC_Tcell_62_30 "温度62";
CM_ SG_ 2400382558 CSC_Tcell_63_30 "温度63";
CM_ SG_ 2400382558 CSC_Tcell_64_30 "温度64";
CM_ SG_ 2400382558 CSC_Tcell_65_30 "温度65";
CM_ SG_ 2400382558 CSC_Tcell_66_30 "温度66";
CM_ SG_ 2400382558 CSC_Tcell_67_30 "温度67";
CM_ SG_ 2400382558 CSC_Tcell_68_30 "温度68";
CM_ SG_ 2400382558 CSC_Tcell_69_30 "温度69";
CM_ SG_ 2400382558 CSC_Tcell_70_30 "温度70";
CM_ SG_ 2400382558 CSC_Tcell_71_30 "温度71";
CM_ SG_ 2400382558 CSC_Tcell_72_30 "温度72";
CM_ SG_ 2400382559 CSC_T_No_31 "CSC号";
CM_ SG_ 2400382559 CSC_Tcell_Frame_Index_31 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382559 CSC_Tcell_01_31 "温度01";
CM_ SG_ 2400382559 CSC_Tcell_02_31 "温度02";
CM_ SG_ 2400382559 CSC_Tcell_03_31 "温度03";
CM_ SG_ 2400382559 CSC_Tcell_04_31 "温度04";
CM_ SG_ 2400382559 CSC_Tcell_05_31 "温度05";
CM_ SG_ 2400382559 CSC_Tcell_06_31 "温度06";
CM_ SG_ 2400382559 CSC_Tcell_07_31 "温度07";
CM_ SG_ 2400382559 CSC_Tcell_08_31 "温度08";
CM_ SG_ 2400382559 CSC_Tcell_09_31 "温度09";
CM_ SG_ 2400382559 CSC_Tcell_10_31 "温度10";
CM_ SG_ 2400382559 CSC_Tcell_11_31 "温度11";
CM_ SG_ 2400382559 CSC_Tcell_12_31 "温度12";
CM_ SG_ 2400382559 CSC_Tcell_13_31 "温度13";
CM_ SG_ 2400382559 CSC_Tcell_14_31 "温度14";
CM_ SG_ 2400382559 CSC_Tcell_15_31 "温度15";
CM_ SG_ 2400382559 CSC_Tcell_16_31 "温度16";
CM_ SG_ 2400382559 CSC_Tcell_17_31 "温度17";
CM_ SG_ 2400382559 CSC_Tcell_18_31 "温度18";
CM_ SG_ 2400382559 CSC_Tcell_19_31 "温度19";
CM_ SG_ 2400382559 CSC_Tcell_20_31 "温度20";
CM_ SG_ 2400382559 CSC_Tcell_21_31 "温度21";
CM_ SG_ 2400382559 CSC_Tcell_22_31 "温度22";
CM_ SG_ 2400382559 CSC_Tcell_23_31 "温度23";
CM_ SG_ 2400382559 CSC_Tcell_24_31 "温度24";
CM_ SG_ 2400382559 CSC_Tcell_25_31 "温度25";
CM_ SG_ 2400382559 CSC_Tcell_26_31 "温度26";
CM_ SG_ 2400382559 CSC_Tcell_27_31 "温度27";
CM_ SG_ 2400382559 CSC_Tcell_28_31 "温度28";
CM_ SG_ 2400382559 CSC_Tcell_29_31 "温度29";
CM_ SG_ 2400382559 CSC_Tcell_30_31 "温度30";
CM_ SG_ 2400382559 CSC_Tcell_31_31 "温度31";
CM_ SG_ 2400382559 CSC_Tcell_32_31 "温度32";
CM_ SG_ 2400382559 CSC_Tcell_33_31 "温度33";
CM_ SG_ 2400382559 CSC_Tcell_34_31 "温度34";
CM_ SG_ 2400382559 CSC_Tcell_35_31 "温度35";
CM_ SG_ 2400382559 CSC_Tcell_36_31 "温度36";
CM_ SG_ 2400382559 CSC_Tcell_37_31 "温度37";
CM_ SG_ 2400382559 CSC_Tcell_38_31 "温度38";
CM_ SG_ 2400382559 CSC_Tcell_39_31 "温度39";
CM_ SG_ 2400382559 CSC_Tcell_40_31 "温度40";
CM_ SG_ 2400382559 CSC_Tcell_41_31 "温度41";
CM_ SG_ 2400382559 CSC_Tcell_42_31 "温度42";
CM_ SG_ 2400382559 CSC_Tcell_43_31 "温度43";
CM_ SG_ 2400382559 CSC_Tcell_44_31 "温度44";
CM_ SG_ 2400382559 CSC_Tcell_45_31 "温度45";
CM_ SG_ 2400382559 CSC_Tcell_46_31 "温度46";
CM_ SG_ 2400382559 CSC_Tcell_47_31 "温度47";
CM_ SG_ 2400382559 CSC_Tcell_48_31 "温度48";
CM_ SG_ 2400382559 CSC_Tcell_49_31 "温度49";
CM_ SG_ 2400382559 CSC_Tcell_50_31 "温度50";
CM_ SG_ 2400382559 CSC_Tcell_51_31 "温度51";
CM_ SG_ 2400382559 CSC_Tcell_52_31 "温度52";
CM_ SG_ 2400382559 CSC_Tcell_53_31 "温度53";
CM_ SG_ 2400382559 CSC_Tcell_54_31 "温度54";
CM_ SG_ 2400382559 CSC_Tcell_55_31 "温度55";
CM_ SG_ 2400382559 CSC_Tcell_56_31 "温度56";
CM_ SG_ 2400382559 CSC_Tcell_57_31 "温度57";
CM_ SG_ 2400382559 CSC_Tcell_58_31 "温度58";
CM_ SG_ 2400382559 CSC_Tcell_59_31 "温度59";
CM_ SG_ 2400382559 CSC_Tcell_60_31 "温度60";
CM_ SG_ 2400382559 CSC_Tcell_61_31 "温度61";
CM_ SG_ 2400382559 CSC_Tcell_62_31 "温度62";
CM_ SG_ 2400382559 CSC_Tcell_63_31 "温度63";
CM_ SG_ 2400382559 CSC_Tcell_64_31 "温度64";
CM_ SG_ 2400382559 CSC_Tcell_65_31 "温度65";
CM_ SG_ 2400382559 CSC_Tcell_66_31 "温度66";
CM_ SG_ 2400382559 CSC_Tcell_67_31 "温度67";
CM_ SG_ 2400382559 CSC_Tcell_68_31 "温度68";
CM_ SG_ 2400382559 CSC_Tcell_69_31 "温度69";
CM_ SG_ 2400382559 CSC_Tcell_70_31 "温度70";
CM_ SG_ 2400382559 CSC_Tcell_71_31 "温度71";
CM_ SG_ 2400382559 CSC_Tcell_72_31 "温度72";
CM_ SG_ 2400382560 CSC_T_No_32 "CSC号";
CM_ SG_ 2400382560 CSC_Tcell_Frame_Index_32 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382560 CSC_Tcell_01_32 "温度01";
CM_ SG_ 2400382560 CSC_Tcell_02_32 "温度02";
CM_ SG_ 2400382560 CSC_Tcell_03_32 "温度03";
CM_ SG_ 2400382560 CSC_Tcell_04_32 "温度04";
CM_ SG_ 2400382560 CSC_Tcell_05_32 "温度05";
CM_ SG_ 2400382560 CSC_Tcell_06_32 "温度06";
CM_ SG_ 2400382560 CSC_Tcell_07_32 "温度07";
CM_ SG_ 2400382560 CSC_Tcell_08_32 "温度08";
CM_ SG_ 2400382560 CSC_Tcell_09_32 "温度09";
CM_ SG_ 2400382560 CSC_Tcell_10_32 "温度10";
CM_ SG_ 2400382560 CSC_Tcell_11_32 "温度11";
CM_ SG_ 2400382560 CSC_Tcell_12_32 "温度12";
CM_ SG_ 2400382560 CSC_Tcell_13_32 "温度13";
CM_ SG_ 2400382560 CSC_Tcell_14_32 "温度14";
CM_ SG_ 2400382560 CSC_Tcell_15_32 "温度15";
CM_ SG_ 2400382560 CSC_Tcell_16_32 "温度16";
CM_ SG_ 2400382560 CSC_Tcell_17_32 "温度17";
CM_ SG_ 2400382560 CSC_Tcell_18_32 "温度18";
CM_ SG_ 2400382560 CSC_Tcell_19_32 "温度19";
CM_ SG_ 2400382560 CSC_Tcell_20_32 "温度20";
CM_ SG_ 2400382560 CSC_Tcell_21_32 "温度21";
CM_ SG_ 2400382560 CSC_Tcell_22_32 "温度22";
CM_ SG_ 2400382560 CSC_Tcell_23_32 "温度23";
CM_ SG_ 2400382560 CSC_Tcell_24_32 "温度24";
CM_ SG_ 2400382560 CSC_Tcell_25_32 "温度25";
CM_ SG_ 2400382560 CSC_Tcell_26_32 "温度26";
CM_ SG_ 2400382560 CSC_Tcell_27_32 "温度27";
CM_ SG_ 2400382560 CSC_Tcell_28_32 "温度28";
CM_ SG_ 2400382560 CSC_Tcell_29_32 "温度29";
CM_ SG_ 2400382560 CSC_Tcell_30_32 "温度30";
CM_ SG_ 2400382560 CSC_Tcell_31_32 "温度31";
CM_ SG_ 2400382560 CSC_Tcell_32_32 "温度32";
CM_ SG_ 2400382560 CSC_Tcell_33_32 "温度33";
CM_ SG_ 2400382560 CSC_Tcell_34_32 "温度34";
CM_ SG_ 2400382560 CSC_Tcell_35_32 "温度35";
CM_ SG_ 2400382560 CSC_Tcell_36_32 "温度36";
CM_ SG_ 2400382560 CSC_Tcell_37_32 "温度37";
CM_ SG_ 2400382560 CSC_Tcell_38_32 "温度38";
CM_ SG_ 2400382560 CSC_Tcell_39_32 "温度39";
CM_ SG_ 2400382560 CSC_Tcell_40_32 "温度40";
CM_ SG_ 2400382560 CSC_Tcell_41_32 "温度41";
CM_ SG_ 2400382560 CSC_Tcell_42_32 "温度42";
CM_ SG_ 2400382560 CSC_Tcell_43_32 "温度43";
CM_ SG_ 2400382560 CSC_Tcell_44_32 "温度44";
CM_ SG_ 2400382560 CSC_Tcell_45_32 "温度45";
CM_ SG_ 2400382560 CSC_Tcell_46_32 "温度46";
CM_ SG_ 2400382560 CSC_Tcell_47_32 "温度47";
CM_ SG_ 2400382560 CSC_Tcell_48_32 "温度48";
CM_ SG_ 2400382560 CSC_Tcell_49_32 "温度49";
CM_ SG_ 2400382560 CSC_Tcell_50_32 "温度50";
CM_ SG_ 2400382560 CSC_Tcell_51_32 "温度51";
CM_ SG_ 2400382560 CSC_Tcell_52_32 "温度52";
CM_ SG_ 2400382560 CSC_Tcell_53_32 "温度53";
CM_ SG_ 2400382560 CSC_Tcell_54_32 "温度54";
CM_ SG_ 2400382560 CSC_Tcell_55_32 "温度55";
CM_ SG_ 2400382560 CSC_Tcell_56_32 "温度56";
CM_ SG_ 2400382560 CSC_Tcell_57_32 "温度57";
CM_ SG_ 2400382560 CSC_Tcell_58_32 "温度58";
CM_ SG_ 2400382560 CSC_Tcell_59_32 "温度59";
CM_ SG_ 2400382560 CSC_Tcell_60_32 "温度60";
CM_ SG_ 2400382560 CSC_Tcell_61_32 "温度61";
CM_ SG_ 2400382560 CSC_Tcell_62_32 "温度62";
CM_ SG_ 2400382560 CSC_Tcell_63_32 "温度63";
CM_ SG_ 2400382560 CSC_Tcell_64_32 "温度64";
CM_ SG_ 2400382560 CSC_Tcell_65_32 "温度65";
CM_ SG_ 2400382560 CSC_Tcell_66_32 "温度66";
CM_ SG_ 2400382560 CSC_Tcell_67_32 "温度67";
CM_ SG_ 2400382560 CSC_Tcell_68_32 "温度68";
CM_ SG_ 2400382560 CSC_Tcell_69_32 "温度69";
CM_ SG_ 2400382560 CSC_Tcell_70_32 "温度70";
CM_ SG_ 2400382560 CSC_Tcell_71_32 "温度71";
CM_ SG_ 2400382560 CSC_Tcell_72_32 "温度72";
CM_ SG_ 2400382561 CSC_T_No_33 "CSC号";
CM_ SG_ 2400382561 CSC_Tcell_Frame_Index_33 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382561 CSC_Tcell_01_33 "温度01";
CM_ SG_ 2400382561 CSC_Tcell_02_33 "温度02";
CM_ SG_ 2400382561 CSC_Tcell_03_33 "温度03";
CM_ SG_ 2400382561 CSC_Tcell_04_33 "温度04";
CM_ SG_ 2400382561 CSC_Tcell_05_33 "温度05";
CM_ SG_ 2400382561 CSC_Tcell_06_33 "温度06";
CM_ SG_ 2400382561 CSC_Tcell_07_33 "温度07";
CM_ SG_ 2400382561 CSC_Tcell_08_33 "温度08";
CM_ SG_ 2400382561 CSC_Tcell_09_33 "温度09";
CM_ SG_ 2400382561 CSC_Tcell_10_33 "温度10";
CM_ SG_ 2400382561 CSC_Tcell_11_33 "温度11";
CM_ SG_ 2400382561 CSC_Tcell_12_33 "温度12";
CM_ SG_ 2400382561 CSC_Tcell_13_33 "温度13";
CM_ SG_ 2400382561 CSC_Tcell_14_33 "温度14";
CM_ SG_ 2400382561 CSC_Tcell_15_33 "温度15";
CM_ SG_ 2400382561 CSC_Tcell_16_33 "温度16";
CM_ SG_ 2400382561 CSC_Tcell_17_33 "温度17";
CM_ SG_ 2400382561 CSC_Tcell_18_33 "温度18";
CM_ SG_ 2400382561 CSC_Tcell_19_33 "温度19";
CM_ SG_ 2400382561 CSC_Tcell_20_33 "温度20";
CM_ SG_ 2400382561 CSC_Tcell_21_33 "温度21";
CM_ SG_ 2400382561 CSC_Tcell_22_33 "温度22";
CM_ SG_ 2400382561 CSC_Tcell_23_33 "温度23";
CM_ SG_ 2400382561 CSC_Tcell_24_33 "温度24";
CM_ SG_ 2400382561 CSC_Tcell_25_33 "温度25";
CM_ SG_ 2400382561 CSC_Tcell_26_33 "温度26";
CM_ SG_ 2400382561 CSC_Tcell_27_33 "温度27";
CM_ SG_ 2400382561 CSC_Tcell_28_33 "温度28";
CM_ SG_ 2400382561 CSC_Tcell_29_33 "温度29";
CM_ SG_ 2400382561 CSC_Tcell_30_33 "温度30";
CM_ SG_ 2400382561 CSC_Tcell_31_33 "温度31";
CM_ SG_ 2400382561 CSC_Tcell_32_33 "温度32";
CM_ SG_ 2400382561 CSC_Tcell_33_33 "温度33";
CM_ SG_ 2400382561 CSC_Tcell_34_33 "温度34";
CM_ SG_ 2400382561 CSC_Tcell_35_33 "温度35";
CM_ SG_ 2400382561 CSC_Tcell_36_33 "温度36";
CM_ SG_ 2400382561 CSC_Tcell_37_33 "温度37";
CM_ SG_ 2400382561 CSC_Tcell_38_33 "温度38";
CM_ SG_ 2400382561 CSC_Tcell_39_33 "温度39";
CM_ SG_ 2400382561 CSC_Tcell_40_33 "温度40";
CM_ SG_ 2400382561 CSC_Tcell_41_33 "温度41";
CM_ SG_ 2400382561 CSC_Tcell_42_33 "温度42";
CM_ SG_ 2400382561 CSC_Tcell_43_33 "温度43";
CM_ SG_ 2400382561 CSC_Tcell_44_33 "温度44";
CM_ SG_ 2400382561 CSC_Tcell_45_33 "温度45";
CM_ SG_ 2400382561 CSC_Tcell_46_33 "温度46";
CM_ SG_ 2400382561 CSC_Tcell_47_33 "温度47";
CM_ SG_ 2400382561 CSC_Tcell_48_33 "温度48";
CM_ SG_ 2400382561 CSC_Tcell_49_33 "温度49";
CM_ SG_ 2400382561 CSC_Tcell_50_33 "温度50";
CM_ SG_ 2400382561 CSC_Tcell_51_33 "温度51";
CM_ SG_ 2400382561 CSC_Tcell_52_33 "温度52";
CM_ SG_ 2400382561 CSC_Tcell_53_33 "温度53";
CM_ SG_ 2400382561 CSC_Tcell_54_33 "温度54";
CM_ SG_ 2400382561 CSC_Tcell_55_33 "温度55";
CM_ SG_ 2400382561 CSC_Tcell_56_33 "温度56";
CM_ SG_ 2400382561 CSC_Tcell_57_33 "温度57";
CM_ SG_ 2400382561 CSC_Tcell_58_33 "温度58";
CM_ SG_ 2400382561 CSC_Tcell_59_33 "温度59";
CM_ SG_ 2400382561 CSC_Tcell_60_33 "温度60";
CM_ SG_ 2400382561 CSC_Tcell_61_33 "温度61";
CM_ SG_ 2400382561 CSC_Tcell_62_33 "温度62";
CM_ SG_ 2400382561 CSC_Tcell_63_33 "温度63";
CM_ SG_ 2400382561 CSC_Tcell_64_33 "温度64";
CM_ SG_ 2400382561 CSC_Tcell_65_33 "温度65";
CM_ SG_ 2400382561 CSC_Tcell_66_33 "温度66";
CM_ SG_ 2400382561 CSC_Tcell_67_33 "温度67";
CM_ SG_ 2400382561 CSC_Tcell_68_33 "温度68";
CM_ SG_ 2400382561 CSC_Tcell_69_33 "温度69";
CM_ SG_ 2400382561 CSC_Tcell_70_33 "温度70";
CM_ SG_ 2400382561 CSC_Tcell_71_33 "温度71";
CM_ SG_ 2400382561 CSC_Tcell_72_33 "温度72";
CM_ SG_ 2400382562 CSC_T_No_34 "CSC号";
CM_ SG_ 2400382562 CSC_Tcell_Frame_Index_34 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382562 CSC_Tcell_01_34 "温度01";
CM_ SG_ 2400382562 CSC_Tcell_02_34 "温度02";
CM_ SG_ 2400382562 CSC_Tcell_03_34 "温度03";
CM_ SG_ 2400382562 CSC_Tcell_04_34 "温度04";
CM_ SG_ 2400382562 CSC_Tcell_05_34 "温度05";
CM_ SG_ 2400382562 CSC_Tcell_06_34 "温度06";
CM_ SG_ 2400382562 CSC_Tcell_07_34 "温度07";
CM_ SG_ 2400382562 CSC_Tcell_08_34 "温度08";
CM_ SG_ 2400382562 CSC_Tcell_09_34 "温度09";
CM_ SG_ 2400382562 CSC_Tcell_10_34 "温度10";
CM_ SG_ 2400382562 CSC_Tcell_11_34 "温度11";
CM_ SG_ 2400382562 CSC_Tcell_12_34 "温度12";
CM_ SG_ 2400382562 CSC_Tcell_13_34 "温度13";
CM_ SG_ 2400382562 CSC_Tcell_14_34 "温度14";
CM_ SG_ 2400382562 CSC_Tcell_15_34 "温度15";
CM_ SG_ 2400382562 CSC_Tcell_16_34 "温度16";
CM_ SG_ 2400382562 CSC_Tcell_17_34 "温度17";
CM_ SG_ 2400382562 CSC_Tcell_18_34 "温度18";
CM_ SG_ 2400382562 CSC_Tcell_19_34 "温度19";
CM_ SG_ 2400382562 CSC_Tcell_20_34 "温度20";
CM_ SG_ 2400382562 CSC_Tcell_21_34 "温度21";
CM_ SG_ 2400382562 CSC_Tcell_22_34 "温度22";
CM_ SG_ 2400382562 CSC_Tcell_23_34 "温度23";
CM_ SG_ 2400382562 CSC_Tcell_24_34 "温度24";
CM_ SG_ 2400382562 CSC_Tcell_25_34 "温度25";
CM_ SG_ 2400382562 CSC_Tcell_26_34 "温度26";
CM_ SG_ 2400382562 CSC_Tcell_27_34 "温度27";
CM_ SG_ 2400382562 CSC_Tcell_28_34 "温度28";
CM_ SG_ 2400382562 CSC_Tcell_29_34 "温度29";
CM_ SG_ 2400382562 CSC_Tcell_30_34 "温度30";
CM_ SG_ 2400382562 CSC_Tcell_31_34 "温度31";
CM_ SG_ 2400382562 CSC_Tcell_32_34 "温度32";
CM_ SG_ 2400382562 CSC_Tcell_33_34 "温度33";
CM_ SG_ 2400382562 CSC_Tcell_34_34 "温度34";
CM_ SG_ 2400382562 CSC_Tcell_35_34 "温度35";
CM_ SG_ 2400382562 CSC_Tcell_36_34 "温度36";
CM_ SG_ 2400382562 CSC_Tcell_37_34 "温度37";
CM_ SG_ 2400382562 CSC_Tcell_38_34 "温度38";
CM_ SG_ 2400382562 CSC_Tcell_39_34 "温度39";
CM_ SG_ 2400382562 CSC_Tcell_40_34 "温度40";
CM_ SG_ 2400382562 CSC_Tcell_41_34 "温度41";
CM_ SG_ 2400382562 CSC_Tcell_42_34 "温度42";
CM_ SG_ 2400382562 CSC_Tcell_43_34 "温度43";
CM_ SG_ 2400382562 CSC_Tcell_44_34 "温度44";
CM_ SG_ 2400382562 CSC_Tcell_45_34 "温度45";
CM_ SG_ 2400382562 CSC_Tcell_46_34 "温度46";
CM_ SG_ 2400382562 CSC_Tcell_47_34 "温度47";
CM_ SG_ 2400382562 CSC_Tcell_48_34 "温度48";
CM_ SG_ 2400382562 CSC_Tcell_49_34 "温度49";
CM_ SG_ 2400382562 CSC_Tcell_50_34 "温度50";
CM_ SG_ 2400382562 CSC_Tcell_51_34 "温度51";
CM_ SG_ 2400382562 CSC_Tcell_52_34 "温度52";
CM_ SG_ 2400382562 CSC_Tcell_53_34 "温度53";
CM_ SG_ 2400382562 CSC_Tcell_54_34 "温度54";
CM_ SG_ 2400382562 CSC_Tcell_55_34 "温度55";
CM_ SG_ 2400382562 CSC_Tcell_56_34 "温度56";
CM_ SG_ 2400382562 CSC_Tcell_57_34 "温度57";
CM_ SG_ 2400382562 CSC_Tcell_58_34 "温度58";
CM_ SG_ 2400382562 CSC_Tcell_59_34 "温度59";
CM_ SG_ 2400382562 CSC_Tcell_60_34 "温度60";
CM_ SG_ 2400382562 CSC_Tcell_61_34 "温度61";
CM_ SG_ 2400382562 CSC_Tcell_62_34 "温度62";
CM_ SG_ 2400382562 CSC_Tcell_63_34 "温度63";
CM_ SG_ 2400382562 CSC_Tcell_64_34 "温度64";
CM_ SG_ 2400382562 CSC_Tcell_65_34 "温度65";
CM_ SG_ 2400382562 CSC_Tcell_66_34 "温度66";
CM_ SG_ 2400382562 CSC_Tcell_67_34 "温度67";
CM_ SG_ 2400382562 CSC_Tcell_68_34 "温度68";
CM_ SG_ 2400382562 CSC_Tcell_69_34 "温度69";
CM_ SG_ 2400382562 CSC_Tcell_70_34 "温度70";
CM_ SG_ 2400382562 CSC_Tcell_71_34 "温度71";
CM_ SG_ 2400382562 CSC_Tcell_72_34 "温度72";
CM_ SG_ 2400382563 CSC_T_No_35 "CSC号";
CM_ SG_ 2400382563 CSC_Tcell_Frame_Index_35 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382563 CSC_Tcell_01_35 "温度01";
CM_ SG_ 2400382563 CSC_Tcell_02_35 "温度02";
CM_ SG_ 2400382563 CSC_Tcell_03_35 "温度03";
CM_ SG_ 2400382563 CSC_Tcell_04_35 "温度04";
CM_ SG_ 2400382563 CSC_Tcell_05_35 "温度05";
CM_ SG_ 2400382563 CSC_Tcell_06_35 "温度06";
CM_ SG_ 2400382563 CSC_Tcell_07_35 "温度07";
CM_ SG_ 2400382563 CSC_Tcell_08_35 "温度08";
CM_ SG_ 2400382563 CSC_Tcell_09_35 "温度09";
CM_ SG_ 2400382563 CSC_Tcell_10_35 "温度10";
CM_ SG_ 2400382563 CSC_Tcell_11_35 "温度11";
CM_ SG_ 2400382563 CSC_Tcell_12_35 "温度12";
CM_ SG_ 2400382563 CSC_Tcell_13_35 "温度13";
CM_ SG_ 2400382563 CSC_Tcell_14_35 "温度14";
CM_ SG_ 2400382563 CSC_Tcell_15_35 "温度15";
CM_ SG_ 2400382563 CSC_Tcell_16_35 "温度16";
CM_ SG_ 2400382563 CSC_Tcell_17_35 "温度17";
CM_ SG_ 2400382563 CSC_Tcell_18_35 "温度18";
CM_ SG_ 2400382563 CSC_Tcell_19_35 "温度19";
CM_ SG_ 2400382563 CSC_Tcell_20_35 "温度20";
CM_ SG_ 2400382563 CSC_Tcell_21_35 "温度21";
CM_ SG_ 2400382563 CSC_Tcell_22_35 "温度22";
CM_ SG_ 2400382563 CSC_Tcell_23_35 "温度23";
CM_ SG_ 2400382563 CSC_Tcell_24_35 "温度24";
CM_ SG_ 2400382563 CSC_Tcell_25_35 "温度25";
CM_ SG_ 2400382563 CSC_Tcell_26_35 "温度26";
CM_ SG_ 2400382563 CSC_Tcell_27_35 "温度27";
CM_ SG_ 2400382563 CSC_Tcell_28_35 "温度28";
CM_ SG_ 2400382563 CSC_Tcell_29_35 "温度29";
CM_ SG_ 2400382563 CSC_Tcell_30_35 "温度30";
CM_ SG_ 2400382563 CSC_Tcell_31_35 "温度31";
CM_ SG_ 2400382563 CSC_Tcell_32_35 "温度32";
CM_ SG_ 2400382563 CSC_Tcell_33_35 "温度33";
CM_ SG_ 2400382563 CSC_Tcell_34_35 "温度34";
CM_ SG_ 2400382563 CSC_Tcell_35_35 "温度35";
CM_ SG_ 2400382563 CSC_Tcell_36_35 "温度36";
CM_ SG_ 2400382563 CSC_Tcell_37_35 "温度37";
CM_ SG_ 2400382563 CSC_Tcell_38_35 "温度38";
CM_ SG_ 2400382563 CSC_Tcell_39_35 "温度39";
CM_ SG_ 2400382563 CSC_Tcell_40_35 "温度40";
CM_ SG_ 2400382563 CSC_Tcell_41_35 "温度41";
CM_ SG_ 2400382563 CSC_Tcell_42_35 "温度42";
CM_ SG_ 2400382563 CSC_Tcell_43_35 "温度43";
CM_ SG_ 2400382563 CSC_Tcell_44_35 "温度44";
CM_ SG_ 2400382563 CSC_Tcell_45_35 "温度45";
CM_ SG_ 2400382563 CSC_Tcell_46_35 "温度46";
CM_ SG_ 2400382563 CSC_Tcell_47_35 "温度47";
CM_ SG_ 2400382563 CSC_Tcell_48_35 "温度48";
CM_ SG_ 2400382563 CSC_Tcell_49_35 "温度49";
CM_ SG_ 2400382563 CSC_Tcell_50_35 "温度50";
CM_ SG_ 2400382563 CSC_Tcell_51_35 "温度51";
CM_ SG_ 2400382563 CSC_Tcell_52_35 "温度52";
CM_ SG_ 2400382563 CSC_Tcell_53_35 "温度53";
CM_ SG_ 2400382563 CSC_Tcell_54_35 "温度54";
CM_ SG_ 2400382563 CSC_Tcell_55_35 "温度55";
CM_ SG_ 2400382563 CSC_Tcell_56_35 "温度56";
CM_ SG_ 2400382563 CSC_Tcell_57_35 "温度57";
CM_ SG_ 2400382563 CSC_Tcell_58_35 "温度58";
CM_ SG_ 2400382563 CSC_Tcell_59_35 "温度59";
CM_ SG_ 2400382563 CSC_Tcell_60_35 "温度60";
CM_ SG_ 2400382563 CSC_Tcell_61_35 "温度61";
CM_ SG_ 2400382563 CSC_Tcell_62_35 "温度62";
CM_ SG_ 2400382563 CSC_Tcell_63_35 "温度63";
CM_ SG_ 2400382563 CSC_Tcell_64_35 "温度64";
CM_ SG_ 2400382563 CSC_Tcell_65_35 "温度65";
CM_ SG_ 2400382563 CSC_Tcell_66_35 "温度66";
CM_ SG_ 2400382563 CSC_Tcell_67_35 "温度67";
CM_ SG_ 2400382563 CSC_Tcell_68_35 "温度68";
CM_ SG_ 2400382563 CSC_Tcell_69_35 "温度69";
CM_ SG_ 2400382563 CSC_Tcell_70_35 "温度70";
CM_ SG_ 2400382563 CSC_Tcell_71_35 "温度71";
CM_ SG_ 2400382563 CSC_Tcell_72_35 "温度72";
CM_ SG_ 2400382564 CSC_T_No_36 "CSC号";
CM_ SG_ 2400382564 CSC_Tcell_Frame_Index_36 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382564 CSC_Tcell_01_36 "温度01";
CM_ SG_ 2400382564 CSC_Tcell_02_36 "温度02";
CM_ SG_ 2400382564 CSC_Tcell_03_36 "温度03";
CM_ SG_ 2400382564 CSC_Tcell_04_36 "温度04";
CM_ SG_ 2400382564 CSC_Tcell_05_36 "温度05";
CM_ SG_ 2400382564 CSC_Tcell_06_36 "温度06";
CM_ SG_ 2400382564 CSC_Tcell_07_36 "温度07";
CM_ SG_ 2400382564 CSC_Tcell_08_36 "温度08";
CM_ SG_ 2400382564 CSC_Tcell_09_36 "温度09";
CM_ SG_ 2400382564 CSC_Tcell_10_36 "温度10";
CM_ SG_ 2400382564 CSC_Tcell_11_36 "温度11";
CM_ SG_ 2400382564 CSC_Tcell_12_36 "温度12";
CM_ SG_ 2400382564 CSC_Tcell_13_36 "温度13";
CM_ SG_ 2400382564 CSC_Tcell_14_36 "温度14";
CM_ SG_ 2400382564 CSC_Tcell_15_36 "温度15";
CM_ SG_ 2400382564 CSC_Tcell_16_36 "温度16";
CM_ SG_ 2400382564 CSC_Tcell_17_36 "温度17";
CM_ SG_ 2400382564 CSC_Tcell_18_36 "温度18";
CM_ SG_ 2400382564 CSC_Tcell_19_36 "温度19";
CM_ SG_ 2400382564 CSC_Tcell_20_36 "温度20";
CM_ SG_ 2400382564 CSC_Tcell_21_36 "温度21";
CM_ SG_ 2400382564 CSC_Tcell_22_36 "温度22";
CM_ SG_ 2400382564 CSC_Tcell_23_36 "温度23";
CM_ SG_ 2400382564 CSC_Tcell_24_36 "温度24";
CM_ SG_ 2400382564 CSC_Tcell_25_36 "温度25";
CM_ SG_ 2400382564 CSC_Tcell_26_36 "温度26";
CM_ SG_ 2400382564 CSC_Tcell_27_36 "温度27";
CM_ SG_ 2400382564 CSC_Tcell_28_36 "温度28";
CM_ SG_ 2400382564 CSC_Tcell_29_36 "温度29";
CM_ SG_ 2400382564 CSC_Tcell_30_36 "温度30";
CM_ SG_ 2400382564 CSC_Tcell_31_36 "温度31";
CM_ SG_ 2400382564 CSC_Tcell_32_36 "温度32";
CM_ SG_ 2400382564 CSC_Tcell_33_36 "温度33";
CM_ SG_ 2400382564 CSC_Tcell_34_36 "温度34";
CM_ SG_ 2400382564 CSC_Tcell_35_36 "温度35";
CM_ SG_ 2400382564 CSC_Tcell_36_36 "温度36";
CM_ SG_ 2400382564 CSC_Tcell_37_36 "温度37";
CM_ SG_ 2400382564 CSC_Tcell_38_36 "温度38";
CM_ SG_ 2400382564 CSC_Tcell_39_36 "温度39";
CM_ SG_ 2400382564 CSC_Tcell_40_36 "温度40";
CM_ SG_ 2400382564 CSC_Tcell_41_36 "温度41";
CM_ SG_ 2400382564 CSC_Tcell_42_36 "温度42";
CM_ SG_ 2400382564 CSC_Tcell_43_36 "温度43";
CM_ SG_ 2400382564 CSC_Tcell_44_36 "温度44";
CM_ SG_ 2400382564 CSC_Tcell_45_36 "温度45";
CM_ SG_ 2400382564 CSC_Tcell_46_36 "温度46";
CM_ SG_ 2400382564 CSC_Tcell_47_36 "温度47";
CM_ SG_ 2400382564 CSC_Tcell_48_36 "温度48";
CM_ SG_ 2400382564 CSC_Tcell_49_36 "温度49";
CM_ SG_ 2400382564 CSC_Tcell_50_36 "温度50";
CM_ SG_ 2400382564 CSC_Tcell_51_36 "温度51";
CM_ SG_ 2400382564 CSC_Tcell_52_36 "温度52";
CM_ SG_ 2400382564 CSC_Tcell_53_36 "温度53";
CM_ SG_ 2400382564 CSC_Tcell_54_36 "温度54";
CM_ SG_ 2400382564 CSC_Tcell_55_36 "温度55";
CM_ SG_ 2400382564 CSC_Tcell_56_36 "温度56";
CM_ SG_ 2400382564 CSC_Tcell_57_36 "温度57";
CM_ SG_ 2400382564 CSC_Tcell_58_36 "温度58";
CM_ SG_ 2400382564 CSC_Tcell_59_36 "温度59";
CM_ SG_ 2400382564 CSC_Tcell_60_36 "温度60";
CM_ SG_ 2400382564 CSC_Tcell_61_36 "温度61";
CM_ SG_ 2400382564 CSC_Tcell_62_36 "温度62";
CM_ SG_ 2400382564 CSC_Tcell_63_36 "温度63";
CM_ SG_ 2400382564 CSC_Tcell_64_36 "温度64";
CM_ SG_ 2400382564 CSC_Tcell_65_36 "温度65";
CM_ SG_ 2400382564 CSC_Tcell_66_36 "温度66";
CM_ SG_ 2400382564 CSC_Tcell_67_36 "温度67";
CM_ SG_ 2400382564 CSC_Tcell_68_36 "温度68";
CM_ SG_ 2400382564 CSC_Tcell_69_36 "温度69";
CM_ SG_ 2400382564 CSC_Tcell_70_36 "温度70";
CM_ SG_ 2400382564 CSC_Tcell_71_36 "温度71";
CM_ SG_ 2400382564 CSC_Tcell_72_36 "温度72";
CM_ SG_ 2400382565 CSC_T_No_37 "CSC号";
CM_ SG_ 2400382565 CSC_Tcell_Frame_Index_37 "当前CSC中温度数据帧序号";
CM_ SG_ 2400382565 CSC_Tcell_01_37 "温度01";
CM_ SG_ 2400382565 CSC_Tcell_02_37 "温度02";
CM_ SG_ 2400382565 CSC_Tcell_03_37 "温度03";
CM_ SG_ 2400382565 CSC_Tcell_04_37 "温度04";
CM_ SG_ 2400382565 CSC_Tcell_05_37 "温度05";
CM_ SG_ 2400382565 CSC_Tcell_06_37 "温度06";
CM_ SG_ 2400382565 CSC_Tcell_07_37 "温度07";
CM_ SG_ 2400382565 CSC_Tcell_08_37 "温度08";
CM_ SG_ 2400382565 CSC_Tcell_09_37 "温度09";
CM_ SG_ 2400382565 CSC_Tcell_10_37 "温度10";
CM_ SG_ 2400382565 CSC_Tcell_11_37 "温度11";
CM_ SG_ 2400382565 CSC_Tcell_12_37 "温度12";
CM_ SG_ 2400382565 CSC_Tcell_13_37 "温度13";
CM_ SG_ 2400382565 CSC_Tcell_14_37 "温度14";
CM_ SG_ 2400382565 CSC_Tcell_15_37 "温度15";
CM_ SG_ 2400382565 CSC_Tcell_16_37 "温度16";
CM_ SG_ 2400382565 CSC_Tcell_17_37 "温度17";
CM_ SG_ 2400382565 CSC_Tcell_18_37 "温度18";
CM_ SG_ 2400382565 CSC_Tcell_19_37 "温度19";
CM_ SG_ 2400382565 CSC_Tcell_20_37 "温度20";
CM_ SG_ 2400382565 CSC_Tcell_21_37 "温度21";
CM_ SG_ 2400382565 CSC_Tcell_22_37 "温度22";
CM_ SG_ 2400382565 CSC_Tcell_23_37 "温度23";
CM_ SG_ 2400382565 CSC_Tcell_24_37 "温度24";
CM_ SG_ 2400382565 CSC_Tcell_25_37 "温度25";
CM_ SG_ 2400382565 CSC_Tcell_26_37 "温度26";
CM_ SG_ 2400382565 CSC_Tcell_27_37 "温度27";
CM_ SG_ 2400382565 CSC_Tcell_28_37 "温度28";
CM_ SG_ 2400382565 CSC_Tcell_29_37 "温度29";
CM_ SG_ 2400382565 CSC_Tcell_30_37 "温度30";
CM_ SG_ 2400382565 CSC_Tcell_31_37 "温度31";
CM_ SG_ 2400382565 CSC_Tcell_32_37 "温度32";
CM_ SG_ 2400382565 CSC_Tcell_33_37 "温度33";
CM_ SG_ 2400382565 CSC_Tcell_34_37 "温度34";
CM_ SG_ 2400382565 CSC_Tcell_35_37 "温度35";
CM_ SG_ 2400382565 CSC_Tcell_36_37 "温度36";
CM_ SG_ 2400382565 CSC_Tcell_37_37 "温度37";
CM_ SG_ 2400382565 CSC_Tcell_38_37 "温度38";
CM_ SG_ 2400382565 CSC_Tcell_39_37 "温度39";
CM_ SG_ 2400382565 CSC_Tcell_40_37 "温度40";
CM_ SG_ 2400382565 CSC_Tcell_41_37 "温度41";
CM_ SG_ 2400382565 CSC_Tcell_42_37 "温度42";
CM_ SG_ 2400382565 CSC_Tcell_43_37 "温度43";
CM_ SG_ 2400382565 CSC_Tcell_44_37 "温度44";
CM_ SG_ 2400382565 CSC_Tcell_45_37 "温度45";
CM_ SG_ 2400382565 CSC_Tcell_46_37 "温度46";
CM_ SG_ 2400382565 CSC_Tcell_47_37 "温度47";
CM_ SG_ 2400382565 CSC_Tcell_48_37 "温度48";
CM_ SG_ 2400382565 CSC_Tcell_49_37 "温度49";
CM_ SG_ 2400382565 CSC_Tcell_50_37 "温度50";
CM_ SG_ 2400382565 CSC_Tcell_51_37 "温度51";
CM_ SG_ 2400382565 CSC_Tcell_52_37 "温度52";
CM_ SG_ 2400382565 CSC_Tcell_53_37 "温度53";
CM_ SG_ 2400382565 CSC_Tcell_54_37 "温度54";
CM_ SG_ 2400382565 CSC_Tcell_55_37 "温度55";
CM_ SG_ 2400382565 CSC_Tcell_56_37 "温度56";
CM_ SG_ 2400382565 CSC_Tcell_57_37 "温度57";
CM_ SG_ 2400382565 CSC_Tcell_58_37 "温度58";
CM_ SG_ 2400382565 CSC_Tcell_59_37 "温度59";
CM_ SG_ 2400382565 CSC_Tcell_60_37 "温度60";
CM_ SG_ 2400382565 CSC_Tcell_61_37 "温度61";
CM_ SG_ 2400382565 CSC_Tcell_62_37 "温度62";
CM_ SG_ 2400382565 CSC_Tcell_63_37 "温度63";
CM_ SG_ 2400382565 CSC_Tcell_64_37 "温度64";
CM_ SG_ 2400382565 CSC_Tcell_65_37 "温度65";
CM_ SG_ 2400382565 CSC_Tcell_66_37 "温度66";
CM_ SG_ 2400382565 CSC_Tcell_67_37 "温度67";
CM_ SG_ 2400382565 CSC_Tcell_68_37 "温度68";
CM_ SG_ 2400382565 CSC_Tcell_69_37 "温度69";
CM_ SG_ 2400382565 CSC_Tcell_70_37 "温度70";
CM_ SG_ 2400382565 CSC_Tcell_71_37 "温度71";
CM_ SG_ 2400382565 CSC_Tcell_72_37 "温度72";
VAL_ 2400382549 CSC_T_No_21 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382549 CSC_Tcell_01_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_02_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_03_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_04_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_05_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_06_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_07_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_08_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_09_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_10_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_11_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_12_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_13_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_14_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_15_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_16_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_17_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_18_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_19_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_20_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_21_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_22_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_23_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_24_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_25_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_26_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_27_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_28_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_29_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_30_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_31_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_32_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_33_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_34_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_35_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_36_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_37_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_38_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_39_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_40_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_41_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_42_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_43_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_44_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_45_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_46_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_47_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_48_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_49_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_50_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_51_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_52_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_53_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_54_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_55_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_56_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_57_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_58_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_59_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_60_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_61_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_62_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_63_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_64_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_65_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_66_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_67_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_68_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_69_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_70_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_71_21 255 "Invalid" ;
VAL_ 2400382549 CSC_Tcell_72_21 255 "Invalid" ;
VAL_ 2400382550 CSC_T_No_22 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382550 CSC_Tcell_01_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_02_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_03_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_04_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_05_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_06_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_07_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_08_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_09_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_10_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_11_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_12_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_13_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_14_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_15_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_16_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_17_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_18_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_19_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_20_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_21_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_22_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_23_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_24_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_25_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_26_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_27_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_28_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_29_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_30_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_31_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_32_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_33_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_34_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_35_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_36_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_37_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_38_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_39_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_40_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_41_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_42_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_43_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_44_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_45_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_46_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_47_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_48_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_49_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_50_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_51_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_52_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_53_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_54_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_55_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_56_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_57_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_58_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_59_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_60_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_61_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_62_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_63_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_64_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_65_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_66_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_67_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_68_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_69_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_70_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_71_22 255 "Invalid" ;
VAL_ 2400382550 CSC_Tcell_72_22 255 "Invalid" ;
VAL_ 2400382551 CSC_T_No_23 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382551 CSC_Tcell_01_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_02_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_03_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_04_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_05_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_06_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_07_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_08_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_09_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_10_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_11_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_12_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_13_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_14_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_15_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_16_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_17_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_18_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_19_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_20_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_21_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_22_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_23_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_24_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_25_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_26_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_27_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_28_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_29_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_30_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_31_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_32_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_33_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_34_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_35_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_36_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_37_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_38_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_39_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_40_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_41_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_42_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_43_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_44_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_45_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_46_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_47_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_48_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_49_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_50_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_51_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_52_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_53_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_54_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_55_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_56_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_57_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_58_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_59_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_60_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_61_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_62_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_63_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_64_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_65_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_66_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_67_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_68_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_69_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_70_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_71_23 255 "Invalid" ;
VAL_ 2400382551 CSC_Tcell_72_23 255 "Invalid" ;
VAL_ 2400382552 CSC_T_No_24 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382552 CSC_Tcell_01_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_02_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_03_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_04_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_05_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_06_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_07_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_08_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_09_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_10_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_11_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_12_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_13_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_14_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_15_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_16_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_17_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_18_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_19_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_20_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_21_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_22_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_23_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_24_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_25_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_26_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_27_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_28_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_29_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_30_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_31_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_32_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_33_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_34_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_35_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_36_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_37_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_38_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_39_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_40_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_41_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_42_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_43_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_44_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_45_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_46_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_47_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_48_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_49_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_50_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_51_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_52_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_53_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_54_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_55_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_56_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_57_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_58_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_59_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_60_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_61_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_62_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_63_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_64_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_65_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_66_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_67_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_68_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_69_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_70_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_71_24 255 "Invalid" ;
VAL_ 2400382552 CSC_Tcell_72_24 255 "Invalid" ;
VAL_ 2400382553 CSC_T_No_25 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382553 CSC_Tcell_01_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_02_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_03_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_04_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_05_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_06_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_07_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_08_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_09_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_10_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_11_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_12_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_13_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_14_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_15_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_16_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_17_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_18_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_19_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_20_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_21_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_22_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_23_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_24_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_25_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_26_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_27_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_28_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_29_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_30_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_31_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_32_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_33_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_34_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_35_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_36_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_37_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_38_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_39_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_40_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_41_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_42_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_43_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_44_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_45_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_46_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_47_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_48_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_49_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_50_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_51_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_52_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_53_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_54_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_55_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_56_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_57_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_58_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_59_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_60_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_61_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_62_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_63_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_64_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_65_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_66_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_67_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_68_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_69_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_70_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_71_25 255 "Invalid" ;
VAL_ 2400382553 CSC_Tcell_72_25 255 "Invalid" ;
VAL_ 2400382554 CSC_T_No_26 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382554 CSC_Tcell_01_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_02_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_03_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_04_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_05_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_06_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_07_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_08_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_09_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_10_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_11_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_12_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_13_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_14_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_15_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_16_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_17_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_18_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_19_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_20_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_21_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_22_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_23_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_24_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_25_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_26_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_27_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_28_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_29_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_30_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_31_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_32_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_33_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_34_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_35_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_36_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_37_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_38_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_39_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_40_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_41_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_42_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_43_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_44_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_45_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_46_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_47_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_48_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_49_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_50_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_51_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_52_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_53_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_54_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_55_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_56_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_57_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_58_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_59_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_60_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_61_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_62_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_63_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_64_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_65_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_66_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_67_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_68_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_69_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_70_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_71_26 255 "Invalid" ;
VAL_ 2400382554 CSC_Tcell_72_26 255 "Invalid" ;
VAL_ 2400382555 CSC_T_No_27 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382555 CSC_Tcell_01_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_02_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_03_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_04_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_05_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_06_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_07_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_08_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_09_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_10_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_11_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_12_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_13_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_14_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_15_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_16_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_17_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_18_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_19_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_20_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_21_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_22_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_23_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_24_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_25_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_26_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_27_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_28_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_29_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_30_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_31_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_32_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_33_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_34_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_35_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_36_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_37_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_38_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_39_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_40_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_41_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_42_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_43_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_44_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_45_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_46_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_47_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_48_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_49_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_50_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_51_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_52_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_53_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_54_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_55_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_56_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_57_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_58_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_59_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_60_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_61_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_62_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_63_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_64_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_65_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_66_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_67_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_68_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_69_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_70_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_71_27 255 "Invalid" ;
VAL_ 2400382555 CSC_Tcell_72_27 255 "Invalid" ;
VAL_ 2400382556 CSC_T_No_28 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382556 CSC_Tcell_01_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_02_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_03_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_04_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_05_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_06_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_07_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_08_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_09_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_10_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_11_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_12_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_13_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_14_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_15_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_16_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_17_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_18_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_19_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_20_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_21_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_22_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_23_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_24_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_25_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_26_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_27_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_28_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_29_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_30_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_31_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_32_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_33_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_34_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_35_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_36_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_37_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_38_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_39_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_40_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_41_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_42_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_43_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_44_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_45_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_46_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_47_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_48_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_49_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_50_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_51_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_52_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_53_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_54_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_55_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_56_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_57_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_58_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_59_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_60_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_61_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_62_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_63_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_64_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_65_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_66_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_67_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_68_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_69_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_70_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_71_28 255 "Invalid" ;
VAL_ 2400382556 CSC_Tcell_72_28 255 "Invalid" ;
VAL_ 2400382557 CSC_T_No_29 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382557 CSC_Tcell_01_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_02_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_03_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_04_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_05_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_06_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_07_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_08_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_09_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_10_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_11_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_12_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_13_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_14_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_15_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_16_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_17_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_18_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_19_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_20_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_21_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_22_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_23_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_24_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_25_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_26_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_27_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_28_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_29_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_30_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_31_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_32_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_33_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_34_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_35_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_36_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_37_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_38_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_39_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_40_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_41_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_42_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_43_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_44_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_45_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_46_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_47_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_48_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_49_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_50_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_51_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_52_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_53_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_54_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_55_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_56_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_57_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_58_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_59_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_60_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_61_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_62_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_63_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_64_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_65_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_66_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_67_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_68_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_69_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_70_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_71_29 255 "Invalid" ;
VAL_ 2400382557 CSC_Tcell_72_29 255 "Invalid" ;
VAL_ 2400382558 CSC_T_No_30 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382558 CSC_Tcell_01_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_02_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_03_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_04_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_05_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_06_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_07_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_08_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_09_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_10_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_11_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_12_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_13_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_14_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_15_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_16_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_17_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_18_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_19_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_20_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_21_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_22_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_23_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_24_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_25_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_26_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_27_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_28_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_29_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_30_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_31_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_32_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_33_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_34_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_35_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_36_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_37_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_38_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_39_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_40_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_41_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_42_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_43_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_44_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_45_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_46_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_47_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_48_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_49_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_50_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_51_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_52_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_53_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_54_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_55_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_56_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_57_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_58_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_59_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_60_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_61_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_62_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_63_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_64_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_65_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_66_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_67_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_68_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_69_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_70_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_71_30 255 "Invalid" ;
VAL_ 2400382558 CSC_Tcell_72_30 255 "Invalid" ;
VAL_ 2400382559 CSC_T_No_31 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382559 CSC_Tcell_01_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_02_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_03_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_04_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_05_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_06_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_07_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_08_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_09_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_10_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_11_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_12_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_13_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_14_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_15_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_16_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_17_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_18_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_19_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_20_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_21_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_22_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_23_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_24_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_25_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_26_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_27_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_28_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_29_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_30_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_31_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_32_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_33_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_34_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_35_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_36_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_37_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_38_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_39_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_40_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_41_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_42_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_43_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_44_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_45_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_46_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_47_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_48_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_49_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_50_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_51_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_52_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_53_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_54_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_55_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_56_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_57_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_58_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_59_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_60_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_61_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_62_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_63_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_64_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_65_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_66_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_67_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_68_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_69_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_70_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_71_31 255 "Invalid" ;
VAL_ 2400382559 CSC_Tcell_72_31 255 "Invalid" ;
VAL_ 2400382560 CSC_T_No_32 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382560 CSC_Tcell_01_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_02_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_03_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_04_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_05_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_06_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_07_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_08_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_09_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_10_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_11_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_12_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_13_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_14_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_15_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_16_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_17_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_18_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_19_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_20_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_21_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_22_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_23_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_24_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_25_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_26_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_27_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_28_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_29_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_30_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_31_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_32_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_33_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_34_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_35_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_36_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_37_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_38_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_39_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_40_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_41_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_42_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_43_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_44_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_45_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_46_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_47_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_48_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_49_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_50_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_51_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_52_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_53_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_54_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_55_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_56_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_57_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_58_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_59_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_60_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_61_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_62_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_63_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_64_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_65_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_66_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_67_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_68_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_69_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_70_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_71_32 255 "Invalid" ;
VAL_ 2400382560 CSC_Tcell_72_32 255 "Invalid" ;
VAL_ 2400382561 CSC_T_No_33 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382561 CSC_Tcell_01_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_02_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_03_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_04_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_05_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_06_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_07_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_08_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_09_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_10_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_11_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_12_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_13_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_14_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_15_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_16_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_17_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_18_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_19_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_20_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_21_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_22_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_23_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_24_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_25_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_26_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_27_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_28_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_29_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_30_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_31_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_32_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_33_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_34_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_35_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_36_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_37_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_38_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_39_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_40_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_41_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_42_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_43_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_44_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_45_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_46_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_47_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_48_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_49_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_50_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_51_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_52_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_53_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_54_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_55_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_56_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_57_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_58_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_59_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_60_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_61_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_62_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_63_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_64_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_65_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_66_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_67_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_68_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_69_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_70_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_71_33 255 "Invalid" ;
VAL_ 2400382561 CSC_Tcell_72_33 255 "Invalid" ;
VAL_ 2400382562 CSC_T_No_34 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382562 CSC_Tcell_01_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_02_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_03_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_04_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_05_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_06_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_07_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_08_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_09_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_10_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_11_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_12_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_13_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_14_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_15_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_16_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_17_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_18_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_19_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_20_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_21_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_22_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_23_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_24_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_25_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_26_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_27_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_28_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_29_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_30_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_31_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_32_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_33_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_34_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_35_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_36_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_37_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_38_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_39_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_40_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_41_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_42_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_43_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_44_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_45_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_46_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_47_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_48_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_49_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_50_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_51_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_52_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_53_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_54_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_55_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_56_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_57_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_58_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_59_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_60_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_61_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_62_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_63_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_64_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_65_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_66_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_67_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_68_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_69_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_70_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_71_34 255 "Invalid" ;
VAL_ 2400382562 CSC_Tcell_72_34 255 "Invalid" ;
VAL_ 2400382563 CSC_T_No_35 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382563 CSC_Tcell_01_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_02_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_03_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_04_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_05_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_06_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_07_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_08_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_09_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_10_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_11_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_12_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_13_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_14_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_15_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_16_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_17_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_18_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_19_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_20_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_21_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_22_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_23_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_24_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_25_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_26_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_27_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_28_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_29_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_30_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_31_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_32_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_33_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_34_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_35_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_36_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_37_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_38_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_39_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_40_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_41_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_42_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_43_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_44_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_45_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_46_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_47_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_48_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_49_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_50_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_51_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_52_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_53_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_54_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_55_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_56_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_57_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_58_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_59_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_60_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_61_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_62_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_63_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_64_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_65_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_66_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_67_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_68_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_69_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_70_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_71_35 255 "Invalid" ;
VAL_ 2400382563 CSC_Tcell_72_35 255 "Invalid" ;
VAL_ 2400382564 CSC_T_No_36 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382564 CSC_Tcell_01_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_02_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_03_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_04_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_05_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_06_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_07_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_08_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_09_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_10_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_11_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_12_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_13_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_14_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_15_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_16_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_17_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_18_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_19_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_20_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_21_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_22_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_23_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_24_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_25_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_26_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_27_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_28_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_29_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_30_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_31_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_32_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_33_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_34_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_35_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_36_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_37_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_38_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_39_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_40_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_41_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_42_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_43_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_44_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_45_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_46_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_47_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_48_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_49_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_50_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_51_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_52_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_53_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_54_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_55_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_56_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_57_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_58_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_59_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_60_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_61_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_62_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_63_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_64_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_65_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_66_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_67_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_68_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_69_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_70_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_71_36 255 "Invalid" ;
VAL_ 2400382564 CSC_Tcell_72_36 255 "Invalid" ;
VAL_ 2400382565 CSC_T_No_37 1 "CSC 1" 2 "CSC 2" 3 "CSC 3" 4 "CSC 4" 5 "CSC 5" 6 "CSC 6" ;
VAL_ 2400382565 CSC_Tcell_01_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_02_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_03_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_04_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_05_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_06_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_07_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_08_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_09_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_10_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_11_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_12_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_13_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_14_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_15_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_16_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_17_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_18_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_19_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_20_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_21_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_22_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_23_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_24_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_25_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_26_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_27_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_28_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_29_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_30_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_31_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_32_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_33_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_34_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_35_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_36_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_37_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_38_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_39_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_40_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_41_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_42_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_43_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_44_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_45_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_46_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_47_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_48_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_49_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_50_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_51_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_52_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_53_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_54_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_55_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_56_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_57_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_58_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_59_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_60_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_61_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_62_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_63_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_64_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_65_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_66_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_67_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_68_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_69_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_70_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_71_37 255 "Invalid" ;
VAL_ 2400382565 CSC_Tcell_72_37 255 "Invalid" ;
